v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1600 -1390 1600 -1320 {
lab=VDD}
N 1570 -1390 1600 -1390 {
lab=VDD}
N 1600 -1160 1600 -1090 {
lab=VSS}
N 1600 -1090 1620 -1090 {
lab=VSS}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1740 -1240 1830 -1240 {
lab=#net1}
N 2000 -1390 2000 -1320 {
lab=VDD}
N 1970 -1390 2000 -1390 {
lab=VDD}
N 2000 -1160 2000 -1090 {
lab=VSS}
N 2000 -1090 2020 -1090 {
lab=VSS}
N 1830 -1240 1890 -1240 {
lab=#net1}
N 2140 -1240 2230 -1240 {
lab=1}
N 2340 -1390 2340 -1320 {
lab=VDD}
N 2310 -1390 2340 -1390 {
lab=VDD}
N 2340 -1160 2340 -1090 {
lab=VSS}
N 2340 -1090 2360 -1090 {
lab=VSS}
N 2480 -1240 2570 -1240 {
lab=a}
N 1640 -960 1640 -890 {
lab=VDD}
N 1610 -960 1640 -960 {
lab=VDD}
N 1640 -730 1640 -660 {
lab=VSS}
N 1640 -660 1660 -660 {
lab=VSS}
N 1470 -810 1530 -810 {
lab=a}
N 1780 -810 1870 -810 {
lab=#net2}
N 2040 -960 2040 -890 {
lab=VDD}
N 2010 -960 2040 -960 {
lab=VDD}
N 2040 -730 2040 -660 {
lab=VSS}
N 2040 -660 2060 -660 {
lab=VSS}
N 1870 -810 1930 -810 {
lab=#net2}
N 2180 -810 2270 -810 {
lab=2}
N 2380 -960 2380 -890 {
lab=VDD}
N 2350 -960 2380 -960 {
lab=VDD}
N 2380 -730 2380 -660 {
lab=VSS}
N 2380 -660 2400 -660 {
lab=VSS}
N 2520 -810 2610 -810 {
lab=b}
N 1640 -570 1640 -500 {
lab=VDD}
N 1610 -570 1640 -570 {
lab=VDD}
N 1640 -340 1640 -270 {
lab=VSS}
N 1640 -270 1660 -270 {
lab=VSS}
N 1470 -420 1530 -420 {
lab=b}
N 1780 -420 1870 -420 {
lab=#net3}
N 2040 -570 2040 -500 {
lab=VDD}
N 2010 -570 2040 -570 {
lab=VDD}
N 2040 -340 2040 -270 {
lab=VSS}
N 2040 -270 2060 -270 {
lab=VSS}
N 1870 -420 1930 -420 {
lab=#net3}
N 2180 -420 2270 -420 {
lab=3}
N 2380 -570 2380 -500 {
lab=VDD}
N 2350 -570 2380 -570 {
lab=VDD}
N 2380 -340 2380 -270 {
lab=VSS}
N 2380 -270 2400 -270 {
lab=VSS}
N 2520 -420 2610 -420 {
lab=c}
N 1670 -170 1670 -100 {
lab=VDD}
N 1640 -170 1670 -170 {
lab=VDD}
N 1670 60 1670 130 {
lab=VSS}
N 1670 130 1690 130 {
lab=VSS}
N 1500 -20 1560 -20 {
lab=c}
N 1810 -20 1900 -20 {
lab=#net4}
N 2070 -170 2070 -100 {
lab=VDD}
N 2040 -170 2070 -170 {
lab=VDD}
N 2070 60 2070 130 {
lab=VSS}
N 2070 130 2090 130 {
lab=VSS}
N 1900 -20 1960 -20 {
lab=#net4}
N 2210 -20 2300 -20 {
lab=4}
N 2410 -170 2410 -100 {
lab=VDD}
N 2380 -170 2410 -170 {
lab=VDD}
N 2410 60 2410 130 {
lab=VSS}
N 2410 130 2430 130 {
lab=VSS}
N 2550 -20 2640 -20 {
lab=d}
N 3010 -1590 3010 -1520 {
lab=VDD}
N 2980 -1590 3010 -1590 {
lab=VDD}
N 3010 -1360 3010 -1290 {
lab=VSS}
N 3010 -1290 3030 -1290 {
lab=VSS}
N 2860 -1440 2900 -1440 {
lab=#net5}
N 2710 -1530 2710 -1460 {
lab=VIN}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 3730 -1400 3730 -1330 {
lab=VDD}
N 3700 -1400 3730 -1400 {
lab=VDD}
N 3730 -1170 3730 -1100 {
lab=VSS}
N 3730 -1100 3750 -1100 {
lab=VSS}
N 3870 -1250 3960 -1250 {
lab=#net6}
N 4130 -1400 4130 -1330 {
lab=VDD}
N 4100 -1400 4130 -1400 {
lab=VDD}
N 4130 -1170 4130 -1100 {
lab=VSS}
N 4130 -1100 4150 -1100 {
lab=VSS}
N 3960 -1250 4020 -1250 {
lab=#net6}
N 4270 -1250 4360 -1250 {
lab=5}
N 4470 -1400 4470 -1330 {
lab=VDD}
N 4440 -1400 4470 -1400 {
lab=VDD}
N 4470 -1170 4470 -1100 {
lab=VSS}
N 4470 -1100 4490 -1100 {
lab=VSS}
N 4610 -1250 4700 -1250 {
lab=e}
N 3770 -970 3770 -900 {
lab=VDD}
N 3740 -970 3770 -970 {
lab=VDD}
N 3770 -740 3770 -670 {
lab=VSS}
N 3770 -670 3790 -670 {
lab=VSS}
N 3600 -820 3660 -820 {
lab=e}
N 3910 -820 4000 -820 {
lab=#net7}
N 4170 -970 4170 -900 {
lab=VDD}
N 4140 -970 4170 -970 {
lab=VDD}
N 4170 -740 4170 -670 {
lab=VSS}
N 4170 -670 4190 -670 {
lab=VSS}
N 4000 -820 4060 -820 {
lab=#net7}
N 4310 -820 4400 -820 {
lab=6}
N 4510 -970 4510 -900 {
lab=VDD}
N 4480 -970 4510 -970 {
lab=VDD}
N 4510 -740 4510 -670 {
lab=VSS}
N 4510 -670 4530 -670 {
lab=VSS}
N 4650 -820 4740 -820 {
lab=f}
N 3770 -580 3770 -510 {
lab=VDD}
N 3740 -580 3770 -580 {
lab=VDD}
N 3770 -350 3770 -280 {
lab=VSS}
N 3770 -280 3790 -280 {
lab=VSS}
N 3600 -430 3660 -430 {
lab=f}
N 3910 -430 4000 -430 {
lab=#net8}
N 4170 -580 4170 -510 {
lab=VDD}
N 4140 -580 4170 -580 {
lab=VDD}
N 4170 -350 4170 -280 {
lab=VSS}
N 4170 -280 4190 -280 {
lab=VSS}
N 4000 -430 4060 -430 {
lab=#net8}
N 4310 -430 4400 -430 {
lab=7}
N 4510 -580 4510 -510 {
lab=VDD}
N 4480 -580 4510 -580 {
lab=VDD}
N 4510 -350 4510 -280 {
lab=VSS}
N 4510 -280 4530 -280 {
lab=VSS}
N 4650 -430 4740 -430 {
lab=g}
N 3800 -180 3800 -110 {
lab=VDD}
N 3770 -180 3800 -180 {
lab=VDD}
N 3800 50 3800 120 {
lab=VSS}
N 3800 120 3820 120 {
lab=VSS}
N 3630 -30 3690 -30 {
lab=g}
N 3940 -30 4030 -30 {
lab=#net9}
N 4200 -180 4200 -110 {
lab=VDD}
N 4170 -180 4200 -180 {
lab=VDD}
N 4200 50 4200 120 {
lab=VSS}
N 4200 120 4220 120 {
lab=VSS}
N 4030 -30 4090 -30 {
lab=#net9}
N 4340 -30 4430 -30 {
lab=8}
N 4540 -180 4540 -110 {
lab=VDD}
N 4510 -180 4540 -180 {
lab=VDD}
N 4540 50 4540 120 {
lab=VSS}
N 4540 120 4560 120 {
lab=VSS}
N 4680 -30 4770 -30 {
lab=h}
N 3540 -1250 3620 -1250 {
lab=d}
N 5560 -1460 5560 -1390 {
lab=VDD}
N 5530 -1460 5560 -1460 {
lab=VDD}
N 5560 -1230 5560 -1160 {
lab=VSS}
N 5560 -1160 5580 -1160 {
lab=VSS}
N 5700 -1310 5790 -1310 {
lab=#net10}
N 5560 -1010 5560 -940 {
lab=VDD}
N 5530 -1010 5560 -1010 {
lab=VDD}
N 5560 -780 5560 -710 {
lab=VSS}
N 5560 -710 5580 -710 {
lab=VSS}
N 5700 -860 5790 -860 {
lab=#net12}
N 5890 -1070 6020 -1070 {
lab=#net10}
N 5890 -1310 5890 -1070 {
lab=#net10}
N 5790 -1310 5890 -1310 {
lab=#net10}
N 5880 -1030 6020 -1030 {
lab=#net12}
N 5880 -1030 5880 -860 {
lab=#net12}
N 5790 -860 5880 -860 {
lab=#net12}
N 6220 -1060 6340 -1060 {
lab=#net14}
N 6590 -1060 6720 -1060 {
lab=ph1}
N 6450 -1250 6450 -1140 {
lab=VDD}
N 6450 -1250 6490 -1250 {
lab=VDD}
N 6450 -980 6450 -890 {
lab=VSS}
N 6400 -890 6450 -890 {
lab=VSS}
N 5160 -1330 5260 -1330 {
lab=1}
N 5160 -1290 5260 -1290 {
lab=b}
N 5170 -880 5260 -880 {
lab=3}
N 5170 -840 5260 -840 {
lab=d}
N 5620 -570 5620 -500 {
lab=VDD}
N 5590 -570 5620 -570 {
lab=VDD}
N 5620 -340 5620 -270 {
lab=VSS}
N 5620 -270 5640 -270 {
lab=VSS}
N 5760 -420 5850 -420 {
lab=#net15}
N 5620 -120 5620 -50 {
lab=VDD}
N 5590 -120 5620 -120 {
lab=VDD}
N 5620 110 5620 180 {
lab=VSS}
N 5620 180 5640 180 {
lab=VSS}
N 5760 30 5850 30 {
lab=#net17}
N 5950 -180 6080 -180 {
lab=#net15}
N 5950 -420 5950 -180 {
lab=#net15}
N 5850 -420 5950 -420 {
lab=#net15}
N 5940 -140 6080 -140 {
lab=#net17}
N 5940 -140 5940 30 {
lab=#net17}
N 5850 30 5940 30 {
lab=#net17}
N 6280 -170 6400 -170 {
lab=#net19}
N 6650 -170 6780 -170 {
lab=ph2}
N 6510 -360 6510 -250 {
lab=VDD}
N 6510 -360 6550 -360 {
lab=VDD}
N 6510 -90 6510 0 {
lab=VSS}
N 6460 0 6510 0 {
lab=VSS}
N 5220 -440 5320 -440 {
lab=5}
N 5220 -400 5320 -400 {
lab=f}
N 5230 10 5320 10 {
lab=7}
N 5230 50 5320 50 {
lab=h}
N 7210 -630 7330 -630 {
lab=#net20}
N 7580 -630 7710 -630 {
lab=vin2}
N 7440 -820 7440 -710 {
lab=VDD}
N 7440 -820 7480 -820 {
lab=VDD}
N 7440 -550 7440 -460 {
lab=VSS}
N 7390 -460 7440 -460 {
lab=VSS}
N 2760 -1550 2760 -1500 {
lab=VDD}
N 2760 -1550 2800 -1550 {
lab=VDD}
N 2760 -1380 2760 -1320 {
lab=VSS}
N 2760 -1320 2810 -1320 {
lab=VSS}
N 2620 -1420 2710 -1420 {
lab=vin2}
N 2620 -1420 2620 -1340 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 3140 -1440 3210 -1440 {
lab=VOUT}
N 6710 -1060 6950 -1060 {
lab=ph1}
N 6950 -1060 6950 -640 {
lab=ph1}
N 6950 -640 7010 -640 {
lab=ph1}
N 6780 -170 6900 -170 {
lab=ph2}
N 6900 -590 6900 -170 {
lab=ph2}
N 6900 -590 6990 -590 {
lab=ph2}
N 5410 -1310 5450 -1310 {
lab=#net5}
N 5310 -1420 5310 -1370 {
lab=VDD}
N 5310 -1420 5350 -1420 {
lab=VDD}
N 5310 -1250 5310 -1190 {
lab=VSS}
N 5310 -1190 5360 -1190 {
lab=VSS}
N 5410 -860 5450 -860 {
lab=#net5}
N 5310 -970 5310 -920 {
lab=VDD}
N 5310 -970 5350 -970 {
lab=VDD}
N 5310 -800 5310 -740 {
lab=VSS}
N 5310 -740 5360 -740 {
lab=VSS}
N 5470 -420 5510 -420 {
lab=#net5}
N 5370 -530 5370 -480 {
lab=VDD}
N 5370 -530 5410 -530 {
lab=VDD}
N 5370 -360 5370 -300 {
lab=VSS}
N 5370 -300 5420 -300 {
lab=VSS}
N 5470 30 5510 30 {
lab=#net5}
N 5370 -80 5370 -30 {
lab=VDD}
N 5370 -80 5410 -80 {
lab=VDD}
N 5370 90 5370 150 {
lab=VSS}
N 5370 150 5420 150 {
lab=VSS}
N 6130 -270 6130 -220 {
lab=VDD}
N 6130 -270 6170 -270 {
lab=VDD}
N 6130 -100 6130 -40 {
lab=VSS}
N 6130 -40 6180 -40 {
lab=VSS}
N 6230 -160 6280 -160 {}
N 6280 -170 6280 -160 {}
N 6070 -1160 6070 -1110 {
lab=VDD}
N 6070 -1160 6110 -1160 {
lab=VDD}
N 6070 -990 6070 -930 {
lab=VSS}
N 6070 -930 6120 -930 {
lab=VSS}
N 6170 -1050 6220 -1050 {}
N 6220 -1060 6220 -1050 {}
N 7060 -730 7060 -680 {
lab=VDD}
N 7060 -730 7100 -730 {
lab=VDD}
N 7060 -560 7060 -500 {
lab=VSS}
N 7060 -500 7110 -500 {
lab=VSS}
N 7160 -620 7210 -620 {}
N 7210 -630 7210 -620 {}
N 6990 -600 7010 -600 {}
N 6990 -600 6990 -590 {}
N 1870 -20 1870 0 {}
N 1870 60 1870 130 {}
N 1860 -420 1860 -400 {}
N 1860 -340 1860 -270 {}
N 1850 -810 1850 -790 {}
N 1850 -730 1850 -660 {}
N 1830 -1240 1830 -1220 {}
N 1830 -1160 1830 -1090 {}
N 4020 -30 4020 -10 {}
N 4020 50 4020 120 {}
N 4010 -430 4010 -410 {}
N 4010 -350 4010 -280 {}
N 4000 -820 4000 -800 {}
N 4000 -740 4000 -670 {}
N 3980 -1250 3980 -1230 {}
N 3980 -1170 3980 -1100 {}
C {inverter_delay.sym} 1790 -950 0 0 {name=X1}
C {devices/lab_wire.sym} 1580 -1390 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 -1090 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 2190 -950 0 0 {name=X2}
C {devices/lab_wire.sym} 1980 -1390 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2010 -1090 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2200 -1240 0 1 {name=l8 sig_type=std_logic lab=1}
C {inverter_delay.sym} 2530 -950 0 0 {name=X3}
C {devices/lab_wire.sym} 2320 -1390 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2350 -1090 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2540 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {inverter_delay.sym} 1830 -520 0 0 {name=X4}
C {devices/lab_wire.sym} 1620 -960 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -660 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {inverter_delay.sym} 2230 -520 0 0 {name=X5}
C {devices/lab_wire.sym} 2020 -960 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -660 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {inverter_delay.sym} 2570 -520 0 0 {name=X6}
C {devices/lab_wire.sym} 2360 -960 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -660 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {inverter_delay.sym} 1830 -130 0 0 {name=X7}
C {devices/lab_wire.sym} 1620 -570 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -270 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {inverter_delay.sym} 2230 -130 0 0 {name=X8}
C {devices/lab_wire.sym} 2020 -570 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -270 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {inverter_delay.sym} 2570 -130 0 0 {name=X9}
C {devices/lab_wire.sym} 2360 -570 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -270 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {inverter_delay.sym} 1860 270 0 0 {name=X10}
C {devices/lab_wire.sym} 1650 -170 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 130 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1520 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {inverter_delay.sym} 2260 270 0 0 {name=X11}
C {devices/lab_wire.sym} 2050 -170 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2080 130 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2270 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {inverter_delay.sym} 2600 270 0 0 {name=X12}
C {devices/lab_wire.sym} 2390 -170 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2420 130 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2610 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {inverter_delay.sym} 3200 -1150 0 0 {name=X13}
C {devices/lab_wire.sym} 2990 -1590 0 0 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3020 -1290 0 1 {name=l43 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 3920 -960 0 0 {name=X14}
C {devices/lab_wire.sym} 3710 -1400 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1100 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4320 -960 0 0 {name=X15}
C {devices/lab_wire.sym} 4110 -1400 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4140 -1100 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4330 -1250 0 1 {name=l49 sig_type=std_logic lab=5}
C {inverter_delay.sym} 4660 -960 0 0 {name=X16}
C {devices/lab_wire.sym} 4450 -1400 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4480 -1100 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4670 -1250 0 1 {name=l52 sig_type=std_logic lab=e}
C {inverter_delay.sym} 3960 -530 0 0 {name=X17}
C {devices/lab_wire.sym} 3750 -970 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -670 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -820 0 0 {name=l55 sig_type=std_logic lab=e}
C {inverter_delay.sym} 4360 -530 0 0 {name=X18}
C {devices/lab_wire.sym} 4150 -970 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -670 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -820 0 1 {name=l58 sig_type=std_logic lab=6}
C {inverter_delay.sym} 4700 -530 0 0 {name=X19}
C {devices/lab_wire.sym} 4490 -970 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -670 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -820 0 1 {name=l61 sig_type=std_logic lab=f}
C {inverter_delay.sym} 3960 -140 0 0 {name=X20}
C {devices/lab_wire.sym} 3750 -580 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -280 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -430 0 0 {name=l64 sig_type=std_logic lab=f}
C {inverter_delay.sym} 4360 -140 0 0 {name=X21}
C {devices/lab_wire.sym} 4150 -580 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -280 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -430 0 1 {name=l67 sig_type=std_logic lab=7}
C {inverter_delay.sym} 4700 -140 0 0 {name=X22}
C {devices/lab_wire.sym} 4490 -580 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -280 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -430 0 1 {name=l70 sig_type=std_logic lab=g}
C {inverter_delay.sym} 3990 260 0 0 {name=X23}
C {devices/lab_wire.sym} 3780 -180 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3810 120 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3650 -30 0 0 {name=l73 sig_type=std_logic lab=g}
C {inverter_delay.sym} 4390 260 0 0 {name=X24}
C {devices/lab_wire.sym} 4180 -180 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4210 120 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4400 -30 0 1 {name=l76 sig_type=std_logic lab=8}
C {inverter_delay.sym} 4730 260 0 0 {name=X25}
C {devices/lab_wire.sym} 4520 -180 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4550 120 0 1 {name=l78 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4740 -30 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 3570 -1250 0 1 {name=l164 sig_type=std_logic lab=d}
C {inverter_delay.sym} 5750 -1020 0 0 {name=X50}
C {devices/lab_wire.sym} 5540 -1460 0 0 {name=l44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5570 -1160 0 1 {name=l167 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 5750 -570 0 0 {name=X51}
C {devices/lab_wire.sym} 5540 -1010 0 0 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5570 -710 0 1 {name=l169 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 6640 -770 0 0 {name=X52}
C {devices/lab_wire.sym} 6470 -1250 0 0 {name=l173 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6410 -890 0 1 {name=l177 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5210 -1330 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 5210 -1290 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 5200 -880 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 5190 -840 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 6650 -1060 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {inverter_delay.sym} 5810 -130 0 0 {name=X53}
C {devices/lab_wire.sym} 5600 -570 0 0 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 -270 0 1 {name=l184 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 5810 320 0 0 {name=X54}
C {devices/lab_wire.sym} 5600 -120 0 0 {name=l185 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5630 180 0 1 {name=l186 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 6700 120 0 0 {name=X55}
C {devices/lab_wire.sym} 6530 -360 0 0 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6470 0 0 1 {name=l194 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5270 -440 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 5270 -400 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 5260 10 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 5250 50 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 6710 -170 0 0 {name=l199 sig_type=std_logic lab=ph2}
C {inverter_delay.sym} 7630 -340 0 0 {name=X58}
C {devices/lab_wire.sym} 7460 -820 0 0 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7400 -460 0 1 {name=l211 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7640 -630 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2790 -1550 0 0 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2800 -1320 0 1 {name=l235 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2620 -1380 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3210 -1440 0 0 {name=p4 lab=VOUT}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 2690 -1370 0 0 {name=X_NOR1}
C {devices/lab_wire.sym} 5340 -1420 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5350 -1190 0 1 {name=l14 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 5240 -1240 0 0 {name=X_NOR2}
C {devices/lab_wire.sym} 5340 -970 0 0 {name=l24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5350 -740 0 1 {name=l34 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 5240 -790 0 0 {name=X_NOR3}
C {devices/lab_wire.sym} 5400 -530 0 0 {name=l41 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5410 -300 0 1 {name=l46 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 5300 -350 0 0 {name=X_NOR4}
C {devices/lab_wire.sym} 5400 -80 0 0 {name=l80 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5410 150 0 1 {name=l81 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 5300 100 0 0 {name=X_NOR5}
C {devices/lab_wire.sym} 6160 -270 0 0 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6170 -40 0 1 {name=l85 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 6060 -90 0 0 {name=X_NOR6}
C {devices/lab_wire.sym} 6100 -1160 0 0 {name=l82 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6110 -930 0 1 {name=l83 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 6000 -980 0 0 {name=X_NOR7}
C {devices/lab_wire.sym} 7090 -730 0 0 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7100 -500 0 1 {name=l87 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 6990 -550 0 0 {name=X_NOR8}
C {devices/capa.sym} 1870 30 0 0 {name=C1
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1870 110 0 1 {name=l88 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1860 -370 0 0 {name=C2
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1860 -290 0 1 {name=l89 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1850 -760 0 0 {name=C3
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1850 -680 0 1 {name=l90 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1830 -1190 0 0 {name=C4
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1830 -1110 0 1 {name=l91 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4020 20 0 0 {name=C9
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4020 100 0 1 {name=l96 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4010 -380 0 0 {name=C10
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4010 -300 0 1 {name=l97 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4000 -770 0 0 {name=C11
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4000 -690 0 1 {name=l98 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 3980 -1200 0 0 {name=C12
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 3980 -1120 0 1 {name=l99 sig_type=std_logic lab=VSS}
