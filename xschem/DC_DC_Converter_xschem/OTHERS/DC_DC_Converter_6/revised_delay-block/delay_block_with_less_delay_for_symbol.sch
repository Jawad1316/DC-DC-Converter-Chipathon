v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1600 -1390 1600 -1320 {
lab=VDD}
N 1570 -1390 1600 -1390 {
lab=VDD}
N 1600 -1160 1600 -1090 {
lab=VSS}
N 1600 -1090 1620 -1090 {
lab=VSS}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1740 -1240 1830 -1240 {
lab=#net1}
N 2000 -1390 2000 -1320 {
lab=VDD}
N 1970 -1390 2000 -1390 {
lab=VDD}
N 2000 -1160 2000 -1090 {
lab=VSS}
N 2000 -1090 2020 -1090 {
lab=VSS}
N 1830 -1240 1890 -1240 {
lab=#net1}
N 2140 -1240 2230 -1240 {
lab=1}
N 2340 -1390 2340 -1320 {
lab=VDD}
N 2310 -1390 2340 -1390 {
lab=VDD}
N 2340 -1160 2340 -1090 {
lab=VSS}
N 2340 -1090 2360 -1090 {
lab=VSS}
N 2480 -1240 2570 -1240 {
lab=a}
N 1640 -960 1640 -890 {
lab=VDD}
N 1610 -960 1640 -960 {
lab=VDD}
N 1640 -730 1640 -660 {
lab=VSS}
N 1640 -660 1660 -660 {
lab=VSS}
N 1470 -810 1530 -810 {
lab=a}
N 1780 -810 1870 -810 {
lab=#net2}
N 2040 -960 2040 -890 {
lab=VDD}
N 2010 -960 2040 -960 {
lab=VDD}
N 2040 -730 2040 -660 {
lab=VSS}
N 2040 -660 2060 -660 {
lab=VSS}
N 1870 -810 1930 -810 {
lab=#net2}
N 2180 -810 2270 -810 {
lab=2}
N 2380 -960 2380 -890 {
lab=VDD}
N 2350 -960 2380 -960 {
lab=VDD}
N 2380 -730 2380 -660 {
lab=VSS}
N 2380 -660 2400 -660 {
lab=VSS}
N 2520 -810 2610 -810 {
lab=b}
N 1640 -570 1640 -500 {
lab=VDD}
N 1610 -570 1640 -570 {
lab=VDD}
N 1640 -340 1640 -270 {
lab=VSS}
N 1640 -270 1660 -270 {
lab=VSS}
N 1470 -420 1530 -420 {
lab=b}
N 1780 -420 1870 -420 {
lab=#net3}
N 2040 -570 2040 -500 {
lab=VDD}
N 2010 -570 2040 -570 {
lab=VDD}
N 2040 -340 2040 -270 {
lab=VSS}
N 2040 -270 2060 -270 {
lab=VSS}
N 1870 -420 1930 -420 {
lab=#net3}
N 2180 -420 2270 -420 {
lab=3}
N 2380 -570 2380 -500 {
lab=VDD}
N 2350 -570 2380 -570 {
lab=VDD}
N 2380 -340 2380 -270 {
lab=VSS}
N 2380 -270 2400 -270 {
lab=VSS}
N 2520 -420 2610 -420 {
lab=c}
N 1670 -170 1670 -100 {
lab=VDD}
N 1640 -170 1670 -170 {
lab=VDD}
N 1670 60 1670 130 {
lab=VSS}
N 1670 130 1690 130 {
lab=VSS}
N 1500 -20 1560 -20 {
lab=c}
N 1810 -20 1900 -20 {
lab=#net4}
N 2070 -170 2070 -100 {
lab=VDD}
N 2040 -170 2070 -170 {
lab=VDD}
N 2070 60 2070 130 {
lab=VSS}
N 2070 130 2090 130 {
lab=VSS}
N 1900 -20 1960 -20 {
lab=#net4}
N 2210 -20 2300 -20 {
lab=4}
N 2410 -170 2410 -100 {
lab=VDD}
N 2380 -170 2410 -170 {
lab=VDD}
N 2410 60 2410 130 {
lab=VSS}
N 2410 130 2430 130 {
lab=VSS}
N 2550 -20 2640 -20 {
lab=d}
N 3060 -1600 3060 -1530 {
lab=VDD}
N 3030 -1600 3060 -1600 {
lab=VDD}
N 3060 -1370 3060 -1300 {
lab=VSS}
N 3060 -1300 3080 -1300 {
lab=VSS}
N 2910 -1450 2950 -1450 {
lab=#net5}
N 2710 -1530 2710 -1460 {
lab=VIN}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 1840 -810 1840 -790 {
lab=#net2}
N 1800 -1240 1800 -1220 {
lab=#net1}
N 1840 -420 1840 -400 {
lab=#net3}
N 1860 -20 1860 0 {
lab=#net4}
N 3730 -1400 3730 -1330 {
lab=VDD}
N 3700 -1400 3730 -1400 {
lab=VDD}
N 3730 -1170 3730 -1100 {
lab=VSS}
N 3730 -1100 3750 -1100 {
lab=VSS}
N 3870 -1250 3960 -1250 {
lab=#net6}
N 4130 -1400 4130 -1330 {
lab=VDD}
N 4100 -1400 4130 -1400 {
lab=VDD}
N 4130 -1170 4130 -1100 {
lab=VSS}
N 4130 -1100 4150 -1100 {
lab=VSS}
N 3960 -1250 4020 -1250 {
lab=#net6}
N 4270 -1250 4360 -1250 {
lab=5}
N 4470 -1400 4470 -1330 {
lab=VDD}
N 4440 -1400 4470 -1400 {
lab=VDD}
N 4470 -1170 4470 -1100 {
lab=VSS}
N 4470 -1100 4490 -1100 {
lab=VSS}
N 4610 -1250 4700 -1250 {
lab=e}
N 3770 -970 3770 -900 {
lab=VDD}
N 3740 -970 3770 -970 {
lab=VDD}
N 3770 -740 3770 -670 {
lab=VSS}
N 3770 -670 3790 -670 {
lab=VSS}
N 3600 -820 3660 -820 {
lab=e}
N 3910 -820 4000 -820 {
lab=#net7}
N 4170 -970 4170 -900 {
lab=VDD}
N 4140 -970 4170 -970 {
lab=VDD}
N 4170 -740 4170 -670 {
lab=VSS}
N 4170 -670 4190 -670 {
lab=VSS}
N 4000 -820 4060 -820 {
lab=#net7}
N 4310 -820 4400 -820 {
lab=6}
N 4510 -970 4510 -900 {
lab=VDD}
N 4480 -970 4510 -970 {
lab=VDD}
N 4510 -740 4510 -670 {
lab=VSS}
N 4510 -670 4530 -670 {
lab=VSS}
N 4650 -820 4740 -820 {
lab=f}
N 3770 -580 3770 -510 {
lab=VDD}
N 3740 -580 3770 -580 {
lab=VDD}
N 3770 -350 3770 -280 {
lab=VSS}
N 3770 -280 3790 -280 {
lab=VSS}
N 3600 -430 3660 -430 {
lab=f}
N 3910 -430 4000 -430 {
lab=#net8}
N 4170 -580 4170 -510 {
lab=VDD}
N 4140 -580 4170 -580 {
lab=VDD}
N 4170 -350 4170 -280 {
lab=VSS}
N 4170 -280 4190 -280 {
lab=VSS}
N 4000 -430 4060 -430 {
lab=#net8}
N 4310 -430 4400 -430 {
lab=7}
N 4510 -580 4510 -510 {
lab=VDD}
N 4480 -580 4510 -580 {
lab=VDD}
N 4510 -350 4510 -280 {
lab=VSS}
N 4510 -280 4530 -280 {
lab=VSS}
N 4650 -430 4740 -430 {
lab=g}
N 3800 -180 3800 -110 {
lab=VDD}
N 3770 -180 3800 -180 {
lab=VDD}
N 3800 50 3800 120 {
lab=VSS}
N 3800 120 3820 120 {
lab=VSS}
N 3630 -30 3690 -30 {
lab=g}
N 3940 -30 4030 -30 {
lab=#net9}
N 4200 -180 4200 -110 {
lab=VDD}
N 4170 -180 4200 -180 {
lab=VDD}
N 4200 50 4200 120 {
lab=VSS}
N 4200 120 4220 120 {
lab=VSS}
N 4030 -30 4090 -30 {
lab=#net9}
N 4340 -30 4430 -30 {
lab=8}
N 4540 -180 4540 -110 {
lab=VDD}
N 4510 -180 4540 -180 {
lab=VDD}
N 4540 50 4540 120 {
lab=VSS}
N 4540 120 4560 120 {
lab=VSS}
N 4680 -30 4770 -30 {
lab=h}
N 3970 -820 3970 -800 {
lab=#net7}
N 3930 -1250 3930 -1230 {
lab=#net6}
N 3970 -430 3970 -410 {
lab=#net8}
N 3990 -30 3990 -10 {
lab=#net9}
N 3540 -1250 3620 -1250 {
lab=d}
N 3850 390 3850 460 {
lab=VDD}
N 3820 390 3850 390 {
lab=VDD}
N 3850 620 3850 690 {
lab=VSS}
N 3850 690 3870 690 {
lab=VSS}
N 3990 540 4080 540 {
lab=#net10}
N 3700 540 3740 540 {
lab=#net11}
N 3850 840 3850 910 {
lab=VDD}
N 3820 840 3850 840 {
lab=VDD}
N 3850 1070 3850 1140 {
lab=VSS}
N 3850 1140 3870 1140 {
lab=VSS}
N 3990 990 4080 990 {
lab=#net12}
N 3700 990 3740 990 {
lab=#net13}
N 4180 780 4310 780 {
lab=#net10}
N 4180 540 4180 780 {
lab=#net10}
N 4080 540 4180 540 {
lab=#net10}
N 4170 820 4310 820 {
lab=#net12}
N 4170 820 4170 990 {
lab=#net12}
N 4080 990 4170 990 {
lab=#net12}
N 4510 790 4630 790 {
lab=#net14}
N 4880 790 5010 790 {
lab=ph1}
N 4740 600 4740 710 {
lab=VDD}
N 4740 600 4780 600 {
lab=VDD}
N 4740 870 4740 960 {
lab=VSS}
N 4690 960 4740 960 {
lab=VSS}
N 4390 890 4390 990 {
lab=VSS}
N 4340 990 4390 990 {
lab=VSS}
N 4390 600 4390 700 {
lab=VDD}
N 4390 600 4430 600 {
lab=VDD}
N 3580 370 3580 450 {
lab=VDD}
N 3530 370 3580 370 {
lab=VDD}
N 3580 640 3580 710 {
lab=VSS}
N 3580 710 3610 710 {
lab=VSS}
N 3580 830 3580 900 {
lab=VDD}
N 3580 830 3620 830 {
lab=VDD}
N 3580 1090 3580 1160 {
lab=VSS}
N 3580 1160 3620 1160 {
lab=VSS}
N 3400 530 3500 530 {
lab=1}
N 3400 570 3500 570 {
lab=b}
N 3410 980 3500 980 {
lab=3}
N 3410 1020 3500 1020 {
lab=d}
N 3910 1280 3910 1350 {
lab=VDD}
N 3880 1280 3910 1280 {
lab=VDD}
N 3910 1510 3910 1580 {
lab=VSS}
N 3910 1580 3930 1580 {
lab=VSS}
N 4050 1430 4140 1430 {
lab=#net15}
N 3760 1430 3800 1430 {
lab=#net16}
N 3910 1730 3910 1800 {
lab=VDD}
N 3880 1730 3910 1730 {
lab=VDD}
N 3910 1960 3910 2030 {
lab=VSS}
N 3910 2030 3930 2030 {
lab=VSS}
N 4050 1880 4140 1880 {
lab=#net17}
N 3760 1880 3800 1880 {
lab=#net18}
N 4240 1670 4370 1670 {
lab=#net15}
N 4240 1430 4240 1670 {
lab=#net15}
N 4140 1430 4240 1430 {
lab=#net15}
N 4230 1710 4370 1710 {
lab=#net17}
N 4230 1710 4230 1880 {
lab=#net17}
N 4140 1880 4230 1880 {
lab=#net17}
N 4570 1680 4690 1680 {
lab=#net19}
N 4940 1680 5070 1680 {
lab=ph2}
N 4800 1490 4800 1600 {
lab=VDD}
N 4800 1490 4840 1490 {
lab=VDD}
N 4800 1760 4800 1850 {
lab=VSS}
N 4750 1850 4800 1850 {
lab=VSS}
N 4450 1780 4450 1880 {
lab=VSS}
N 4400 1880 4450 1880 {
lab=VSS}
N 4450 1490 4450 1590 {
lab=VDD}
N 4450 1490 4490 1490 {
lab=VDD}
N 3640 1260 3640 1340 {
lab=VDD}
N 3590 1260 3640 1260 {
lab=VDD}
N 3640 1530 3640 1600 {
lab=VSS}
N 3640 1600 3670 1600 {
lab=VSS}
N 3640 1720 3640 1790 {
lab=VDD}
N 3640 1720 3680 1720 {
lab=VDD}
N 3640 1980 3640 2050 {
lab=VSS}
N 3640 2050 3680 2050 {
lab=VSS}
N 3460 1420 3560 1420 {
lab=5}
N 3460 1460 3560 1460 {
lab=f}
N 3470 1870 3560 1870 {
lab=7}
N 3470 1910 3560 1910 {
lab=h}
N 5500 1220 5620 1220 {
lab=#net20}
N 5870 1220 6000 1220 {
lab=vin2}
N 5730 1030 5730 1140 {
lab=VDD}
N 5730 1030 5770 1030 {
lab=VDD}
N 5730 1300 5730 1390 {
lab=VSS}
N 5680 1390 5730 1390 {
lab=VSS}
N 5380 1320 5380 1420 {
lab=VSS}
N 5330 1420 5380 1420 {
lab=VSS}
N 5380 1030 5380 1130 {
lab=VDD}
N 5380 1030 5420 1030 {
lab=VDD}
N 2790 -1590 2790 -1540 {
lab=VDD}
N 2790 -1590 2830 -1590 {
lab=VDD}
N 2790 -1350 2790 -1290 {
lab=VSS}
N 2790 -1290 2840 -1290 {
lab=VSS}
N 2620 -1420 2710 -1420 {
lab=vin2}
N 2620 -1420 2620 -1340 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 3190 -1450 3260 -1450 {
lab=VOUT}
N 5000 790 5240 790 {
lab=ph1}
N 5240 790 5240 1210 {
lab=ph1}
N 5240 1210 5300 1210 {
lab=ph1}
N 5070 1680 5190 1680 {
lab=ph2}
N 5190 1260 5190 1680 {
lab=ph2}
N 5190 1260 5280 1260 {
lab=ph2}
N 5280 1250 5280 1260 {
lab=ph2}
N 5280 1250 5300 1250 {
lab=ph2}
N 5450 -1450 5450 -1380 {
lab=VDD}
N 5420 -1450 5450 -1450 {
lab=VDD}
N 5450 -1220 5450 -1150 {
lab=VSS}
N 5450 -1150 5470 -1150 {
lab=VSS}
N 5590 -1300 5680 -1300 {
lab=#net21}
N 5850 -1450 5850 -1380 {
lab=VDD}
N 5820 -1450 5850 -1450 {
lab=VDD}
N 5850 -1220 5850 -1150 {
lab=VSS}
N 5850 -1150 5870 -1150 {
lab=VSS}
N 5680 -1300 5740 -1300 {
lab=#net21}
N 5990 -1300 6080 -1300 {
lab=9}
N 6190 -1450 6190 -1380 {
lab=VDD}
N 6160 -1450 6190 -1450 {
lab=VDD}
N 6190 -1220 6190 -1150 {
lab=VSS}
N 6190 -1150 6210 -1150 {
lab=VSS}
N 6330 -1300 6420 -1300 {
lab=j}
N 5490 -1020 5490 -950 {
lab=VDD}
N 5460 -1020 5490 -1020 {
lab=VDD}
N 5490 -790 5490 -720 {
lab=VSS}
N 5490 -720 5510 -720 {
lab=VSS}
N 5320 -870 5380 -870 {
lab=j}
N 5630 -870 5720 -870 {
lab=#net22}
N 5890 -1020 5890 -950 {
lab=VDD}
N 5860 -1020 5890 -1020 {
lab=VDD}
N 5890 -790 5890 -720 {
lab=VSS}
N 5890 -720 5910 -720 {
lab=VSS}
N 5720 -870 5780 -870 {
lab=#net22}
N 6030 -870 6120 -870 {
lab=10}
N 6230 -1020 6230 -950 {
lab=VDD}
N 6200 -1020 6230 -1020 {
lab=VDD}
N 6230 -790 6230 -720 {
lab=VSS}
N 6230 -720 6250 -720 {
lab=VSS}
N 6370 -870 6460 -870 {
lab=k}
N 5490 -630 5490 -560 {
lab=VDD}
N 5460 -630 5490 -630 {
lab=VDD}
N 5490 -400 5490 -330 {
lab=VSS}
N 5490 -330 5510 -330 {
lab=VSS}
N 5320 -480 5380 -480 {
lab=k}
N 5630 -480 5720 -480 {
lab=#net23}
N 5890 -630 5890 -560 {
lab=VDD}
N 5860 -630 5890 -630 {
lab=VDD}
N 5890 -400 5890 -330 {
lab=VSS}
N 5890 -330 5910 -330 {
lab=VSS}
N 5720 -480 5780 -480 {
lab=#net23}
N 6030 -480 6120 -480 {
lab=11}
N 6230 -630 6230 -560 {
lab=VDD}
N 6200 -630 6230 -630 {
lab=VDD}
N 6230 -400 6230 -330 {
lab=VSS}
N 6230 -330 6250 -330 {
lab=VSS}
N 6370 -480 6460 -480 {
lab=g}
N 5520 -230 5520 -160 {
lab=VDD}
N 5490 -230 5520 -230 {
lab=VDD}
N 5520 0 5520 70 {
lab=VSS}
N 5520 70 5540 70 {
lab=VSS}
N 5350 -80 5410 -80 {
lab=l}
N 5660 -80 5750 -80 {
lab=#net24}
N 5920 -230 5920 -160 {
lab=VDD}
N 5890 -230 5920 -230 {
lab=VDD}
N 5920 0 5920 70 {
lab=VSS}
N 5920 70 5940 70 {
lab=VSS}
N 5750 -80 5810 -80 {
lab=#net24}
N 6060 -80 6150 -80 {
lab=12}
N 6260 -230 6260 -160 {
lab=VDD}
N 6230 -230 6260 -230 {
lab=VDD}
N 6260 0 6260 70 {
lab=VSS}
N 6260 70 6280 70 {
lab=VSS}
N 6400 -80 6490 -80 {
lab=h}
N 5690 -870 5690 -850 {
lab=#net22}
N 5650 -1300 5650 -1280 {
lab=#net21}
N 5690 -480 5690 -460 {
lab=#net23}
N 5710 -80 5710 -60 {
lab=#net24}
N 5260 -1300 5340 -1300 {
lab=i}
C {inverter_delay.sym} 1790 -950 0 0 {name=X1}
C {devices/lab_wire.sym} 1580 -1390 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 -1090 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 2190 -950 0 0 {name=X2}
C {devices/lab_wire.sym} 1980 -1390 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2010 -1090 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2200 -1240 0 1 {name=l8 sig_type=std_logic lab=1}
C {inverter_delay.sym} 2530 -950 0 0 {name=X3}
C {devices/lab_wire.sym} 2320 -1390 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2350 -1090 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2540 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {inverter_delay.sym} 1830 -520 0 0 {name=X4}
C {devices/lab_wire.sym} 1620 -960 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -660 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {inverter_delay.sym} 2230 -520 0 0 {name=X5}
C {devices/lab_wire.sym} 2020 -960 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -660 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {inverter_delay.sym} 2570 -520 0 0 {name=X6}
C {devices/lab_wire.sym} 2360 -960 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -660 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {inverter_delay.sym} 1830 -130 0 0 {name=X7}
C {devices/lab_wire.sym} 1620 -570 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -270 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {inverter_delay.sym} 2230 -130 0 0 {name=X8}
C {devices/lab_wire.sym} 2020 -570 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -270 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {inverter_delay.sym} 2570 -130 0 0 {name=X9}
C {devices/lab_wire.sym} 2360 -570 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -270 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {inverter_delay.sym} 1860 270 0 0 {name=X10}
C {devices/lab_wire.sym} 1650 -170 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 130 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1520 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {inverter_delay.sym} 2260 270 0 0 {name=X11}
C {devices/lab_wire.sym} 2050 -170 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2080 130 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2270 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {inverter_delay.sym} 2600 270 0 0 {name=X12}
C {devices/lab_wire.sym} 2390 -170 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2420 130 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2610 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {inverter_delay.sym} 3250 -1160 0 0 {name=X13}
C {devices/lab_wire.sym} 3040 -1600 0 0 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3070 -1300 0 1 {name=l43 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1840 -760 0 0 {name=C1
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1840 -730 0 0 {name=l14 lab=GND}
C {devices/capa.sym} 1800 -1190 0 0 {name=C2
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1800 -1160 0 0 {name=l24 lab=GND}
C {devices/capa.sym} 1840 -370 0 0 {name=C3
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1840 -340 0 0 {name=l34 lab=GND}
C {devices/capa.sym} 1860 30 0 0 {name=C4
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1860 60 0 0 {name=l41 lab=GND}
C {inverter_delay.sym} 3920 -960 0 0 {name=X14}
C {devices/lab_wire.sym} 3710 -1400 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1100 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4320 -960 0 0 {name=X15}
C {devices/lab_wire.sym} 4110 -1400 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4140 -1100 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4330 -1250 0 1 {name=l49 sig_type=std_logic lab=5}
C {inverter_delay.sym} 4660 -960 0 0 {name=X16}
C {devices/lab_wire.sym} 4450 -1400 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4480 -1100 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4670 -1250 0 1 {name=l52 sig_type=std_logic lab=e}
C {inverter_delay.sym} 3960 -530 0 0 {name=X17}
C {devices/lab_wire.sym} 3750 -970 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -670 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -820 0 0 {name=l55 sig_type=std_logic lab=e}
C {inverter_delay.sym} 4360 -530 0 0 {name=X18}
C {devices/lab_wire.sym} 4150 -970 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -670 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -820 0 1 {name=l58 sig_type=std_logic lab=6}
C {inverter_delay.sym} 4700 -530 0 0 {name=X19}
C {devices/lab_wire.sym} 4490 -970 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -670 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -820 0 1 {name=l61 sig_type=std_logic lab=f}
C {inverter_delay.sym} 3960 -140 0 0 {name=X20}
C {devices/lab_wire.sym} 3750 -580 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -280 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -430 0 0 {name=l64 sig_type=std_logic lab=f}
C {inverter_delay.sym} 4360 -140 0 0 {name=X21}
C {devices/lab_wire.sym} 4150 -580 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -280 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -430 0 1 {name=l67 sig_type=std_logic lab=7}
C {inverter_delay.sym} 4700 -140 0 0 {name=X22}
C {devices/lab_wire.sym} 4490 -580 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -280 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -430 0 1 {name=l70 sig_type=std_logic lab=g}
C {inverter_delay.sym} 3990 260 0 0 {name=X23}
C {devices/lab_wire.sym} 3780 -180 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3810 120 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3650 -30 0 0 {name=l73 sig_type=std_logic lab=g}
C {inverter_delay.sym} 4390 260 0 0 {name=X24}
C {devices/lab_wire.sym} 4180 -180 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4210 120 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4400 -30 0 1 {name=l76 sig_type=std_logic lab=8}
C {inverter_delay.sym} 4730 260 0 0 {name=X25}
C {devices/lab_wire.sym} 4520 -180 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4550 120 0 1 {name=l78 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4740 -30 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/capa.sym} 3970 -770 0 0 {name=C5
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 3970 -740 0 0 {name=l80 lab=GND}
C {devices/capa.sym} 3930 -1200 0 0 {name=C6
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 3930 -1170 0 0 {name=l81 lab=GND}
C {devices/capa.sym} 3970 -380 0 0 {name=C7
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 3970 -350 0 0 {name=l82 lab=GND}
C {devices/capa.sym} 3990 20 0 0 {name=C8
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 3990 50 0 0 {name=l83 lab=GND}
C {devices/lab_wire.sym} 3570 -1250 0 1 {name=l164 sig_type=std_logic lab=d}
C {inverter_delay.sym} 4040 830 0 0 {name=X50}
C {devices/lab_wire.sym} 3830 390 0 0 {name=l44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3860 690 0 1 {name=l167 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4040 1280 0 0 {name=X51}
C {devices/lab_wire.sym} 3830 840 0 0 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3860 1140 0 1 {name=l169 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4930 1080 0 0 {name=X52}
C {devices/lab_wire.sym} 3610 830 0 0 {name=l170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3550 370 0 0 {name=l171 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4410 600 0 0 {name=l172 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4760 600 0 0 {name=l173 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3600 710 0 1 {name=l174 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3590 1160 0 1 {name=l175 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4360 990 0 1 {name=l176 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4700 960 0 1 {name=l177 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3450 530 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 3450 570 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 3440 980 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 3430 1020 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 4940 790 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {inverter_delay.sym} 4100 1720 0 0 {name=X53}
C {devices/lab_wire.sym} 3890 1280 0 0 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3920 1580 0 1 {name=l184 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4100 2170 0 0 {name=X54}
C {devices/lab_wire.sym} 3890 1730 0 0 {name=l185 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3920 2030 0 1 {name=l186 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4990 1970 0 0 {name=X55}
C {devices/lab_wire.sym} 3670 1720 0 0 {name=l187 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3610 1260 0 0 {name=l188 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4470 1490 0 0 {name=l189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4820 1490 0 0 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3660 1600 0 1 {name=l191 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3650 2050 0 1 {name=l192 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4420 1880 0 1 {name=l193 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4760 1850 0 1 {name=l194 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3510 1420 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 3510 1460 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 3500 1870 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 3490 1910 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 5000 1680 0 0 {name=l199 sig_type=std_logic lab=ph2}
C {inverter_delay.sym} 5920 1510 0 0 {name=X58}
C {devices/lab_wire.sym} 5400 1030 0 0 {name=l206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5750 1030 0 0 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5350 1420 0 1 {name=l210 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5690 1390 0 1 {name=l211 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5930 1220 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2820 -1590 0 0 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2830 -1290 0 1 {name=l235 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2620 -1380 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {NOR.sym} 2440 -1330 0 0 {name=X62}
C {NOR.sym} 3230 660 0 0 {name=X63}
C {NOR.sym} 3230 1110 0 0 {name=X64}
C {NOR.sym} 4040 910 0 0 {name=X65}
C {NOR.sym} 3290 1550 0 0 {name=X66}
C {NOR.sym} 3290 2000 0 0 {name=X67}
C {NOR.sym} 4100 1800 0 0 {name=X68}
C {NOR.sym} 5030 1340 0 0 {name=X71}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3260 -1450 0 0 {name=p4 lab=VOUT}
C {inverter_delay.sym} 5640 -1010 0 0 {name=X26}
C {devices/lab_wire.sym} 5430 -1450 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5460 -1150 0 1 {name=l46 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 6040 -1010 0 0 {name=X27}
C {devices/lab_wire.sym} 5830 -1450 0 0 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5860 -1150 0 1 {name=l85 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6050 -1300 0 1 {name=l86 sig_type=std_logic lab=9}
C {inverter_delay.sym} 6380 -1010 0 0 {name=X28}
C {devices/lab_wire.sym} 6170 -1450 0 0 {name=l87 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6200 -1150 0 1 {name=l88 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6390 -1300 0 1 {name=l89 sig_type=std_logic lab=j}
C {inverter_delay.sym} 5680 -580 0 0 {name=X29}
C {devices/lab_wire.sym} 5470 -1020 0 0 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5500 -720 0 1 {name=l91 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5340 -870 0 0 {name=l92 sig_type=std_logic lab=j}
C {inverter_delay.sym} 6080 -580 0 0 {name=X30}
C {devices/lab_wire.sym} 5870 -1020 0 0 {name=l93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5900 -720 0 1 {name=l94 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6090 -870 0 1 {name=l95 sig_type=std_logic lab=10}
C {inverter_delay.sym} 6420 -580 0 0 {name=X31}
C {devices/lab_wire.sym} 6210 -1020 0 0 {name=l96 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6240 -720 0 1 {name=l97 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6430 -870 0 1 {name=l98 sig_type=std_logic lab=k}
C {inverter_delay.sym} 5680 -190 0 0 {name=X32}
C {devices/lab_wire.sym} 5470 -630 0 0 {name=l99 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5500 -330 0 1 {name=l100 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5340 -480 0 0 {name=l101 sig_type=std_logic lab=k}
C {inverter_delay.sym} 6080 -190 0 0 {name=X33}
C {devices/lab_wire.sym} 5870 -630 0 0 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5900 -330 0 1 {name=l103 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6090 -480 0 1 {name=l104 sig_type=std_logic lab=11}
C {inverter_delay.sym} 6420 -190 0 0 {name=X34}
C {devices/lab_wire.sym} 6210 -630 0 0 {name=l105 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6240 -330 0 1 {name=l106 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6430 -480 0 1 {name=l107 sig_type=std_logic lab=g}
C {inverter_delay.sym} 5710 210 0 0 {name=X35}
C {devices/lab_wire.sym} 5500 -230 0 0 {name=l108 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5530 70 0 1 {name=l109 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5370 -80 0 0 {name=l110 sig_type=std_logic lab=l}
C {inverter_delay.sym} 6110 210 0 0 {name=X36}
C {devices/lab_wire.sym} 5900 -230 0 0 {name=l111 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5930 70 0 1 {name=l112 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6120 -80 0 1 {name=l113 sig_type=std_logic lab=12}
C {inverter_delay.sym} 6450 210 0 0 {name=X37}
C {devices/lab_wire.sym} 6240 -230 0 0 {name=l114 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6270 70 0 1 {name=l115 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6460 -80 0 1 {name=l116 sig_type=std_logic lab=h}
C {devices/capa.sym} 5690 -820 0 0 {name=C9
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 5690 -790 0 0 {name=l117 lab=GND}
C {devices/capa.sym} 5650 -1250 0 0 {name=C10
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 5650 -1220 0 0 {name=l118 lab=GND}
C {devices/capa.sym} 5690 -430 0 0 {name=C11
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 5690 -400 0 0 {name=l119 lab=GND}
C {devices/capa.sym} 5710 -30 0 0 {name=C12
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 5710 0 0 0 {name=l120 lab=GND}
C {devices/lab_wire.sym} 5290 -1300 0 1 {name=l121 sig_type=std_logic lab=i}
