v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1600 -1390 1600 -1320 {
lab=VDD}
N 1570 -1390 1600 -1390 {
lab=VDD}
N 1600 -1160 1600 -1090 {
lab=VSS}
N 1600 -1090 1620 -1090 {
lab=VSS}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1740 -1240 1830 -1240 {
lab=#net1}
N 2000 -1390 2000 -1320 {
lab=VDD}
N 1970 -1390 2000 -1390 {
lab=VDD}
N 2000 -1160 2000 -1090 {
lab=VSS}
N 2000 -1090 2020 -1090 {
lab=VSS}
N 1830 -1240 1890 -1240 {
lab=#net1}
N 2140 -1240 2230 -1240 {
lab=1}
N 2340 -1390 2340 -1320 {
lab=VDD}
N 2310 -1390 2340 -1390 {
lab=VDD}
N 2340 -1160 2340 -1090 {
lab=VSS}
N 2340 -1090 2360 -1090 {
lab=VSS}
N 2480 -1240 2570 -1240 {
lab=a}
N 1640 -960 1640 -890 {
lab=VDD}
N 1610 -960 1640 -960 {
lab=VDD}
N 1640 -730 1640 -660 {
lab=VSS}
N 1640 -660 1660 -660 {
lab=VSS}
N 1470 -810 1530 -810 {
lab=a}
N 1780 -810 1870 -810 {
lab=#net2}
N 2040 -960 2040 -890 {
lab=VDD}
N 2010 -960 2040 -960 {
lab=VDD}
N 2040 -730 2040 -660 {
lab=VSS}
N 2040 -660 2060 -660 {
lab=VSS}
N 1870 -810 1930 -810 {
lab=#net2}
N 2180 -810 2270 -810 {
lab=2}
N 2380 -960 2380 -890 {
lab=VDD}
N 2350 -960 2380 -960 {
lab=VDD}
N 2380 -730 2380 -660 {
lab=VSS}
N 2380 -660 2400 -660 {
lab=VSS}
N 2520 -810 2610 -810 {
lab=b}
N 1640 -570 1640 -500 {
lab=VDD}
N 1610 -570 1640 -570 {
lab=VDD}
N 1640 -340 1640 -270 {
lab=VSS}
N 1640 -270 1660 -270 {
lab=VSS}
N 1470 -420 1530 -420 {
lab=b}
N 1780 -420 1870 -420 {
lab=#net3}
N 2040 -570 2040 -500 {
lab=VDD}
N 2010 -570 2040 -570 {
lab=VDD}
N 2040 -340 2040 -270 {
lab=VSS}
N 2040 -270 2060 -270 {
lab=VSS}
N 1870 -420 1930 -420 {
lab=#net3}
N 2180 -420 2270 -420 {
lab=3}
N 2380 -570 2380 -500 {
lab=VDD}
N 2350 -570 2380 -570 {
lab=VDD}
N 2380 -340 2380 -270 {
lab=VSS}
N 2380 -270 2400 -270 {
lab=VSS}
N 2520 -420 2610 -420 {
lab=c}
N 1670 -170 1670 -100 {
lab=VDD}
N 1640 -170 1670 -170 {
lab=VDD}
N 1670 60 1670 130 {
lab=VSS}
N 1670 130 1690 130 {
lab=VSS}
N 1500 -20 1560 -20 {
lab=c}
N 1810 -20 1900 -20 {
lab=#net4}
N 2070 -170 2070 -100 {
lab=VDD}
N 2040 -170 2070 -170 {
lab=VDD}
N 2070 60 2070 130 {
lab=VSS}
N 2070 130 2090 130 {
lab=VSS}
N 1900 -20 1960 -20 {
lab=#net4}
N 2210 -20 2300 -20 {
lab=4}
N 2410 -170 2410 -100 {
lab=VDD}
N 2380 -170 2410 -170 {
lab=VDD}
N 2410 60 2410 130 {
lab=VSS}
N 2410 130 2430 130 {
lab=VSS}
N 2550 -20 2640 -20 {
lab=d}
N 3060 -1600 3060 -1530 {
lab=VDD}
N 3030 -1600 3060 -1600 {
lab=VDD}
N 3060 -1370 3060 -1300 {
lab=VSS}
N 3060 -1300 3080 -1300 {
lab=VSS}
N 2910 -1450 2950 -1450 {
lab=#net5}
N 2710 -1530 2710 -1460 {
lab=VIN}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 3730 -1400 3730 -1330 {
lab=VDD}
N 3700 -1400 3730 -1400 {
lab=VDD}
N 3730 -1170 3730 -1100 {
lab=VSS}
N 3730 -1100 3750 -1100 {
lab=VSS}
N 3870 -1250 3960 -1250 {
lab=#net6}
N 4130 -1400 4130 -1330 {
lab=VDD}
N 4100 -1400 4130 -1400 {
lab=VDD}
N 4130 -1170 4130 -1100 {
lab=VSS}
N 4130 -1100 4150 -1100 {
lab=VSS}
N 3960 -1250 4020 -1250 {
lab=#net6}
N 4270 -1250 4360 -1250 {
lab=5}
N 4470 -1400 4470 -1330 {
lab=VDD}
N 4440 -1400 4470 -1400 {
lab=VDD}
N 4470 -1170 4470 -1100 {
lab=VSS}
N 4470 -1100 4490 -1100 {
lab=VSS}
N 4610 -1250 4700 -1250 {
lab=e}
N 3770 -970 3770 -900 {
lab=VDD}
N 3740 -970 3770 -970 {
lab=VDD}
N 3770 -740 3770 -670 {
lab=VSS}
N 3770 -670 3790 -670 {
lab=VSS}
N 3600 -820 3660 -820 {
lab=e}
N 3910 -820 4000 -820 {
lab=#net7}
N 4170 -970 4170 -900 {
lab=VDD}
N 4140 -970 4170 -970 {
lab=VDD}
N 4170 -740 4170 -670 {
lab=VSS}
N 4170 -670 4190 -670 {
lab=VSS}
N 4000 -820 4060 -820 {
lab=#net7}
N 4310 -820 4400 -820 {
lab=6}
N 4510 -970 4510 -900 {
lab=VDD}
N 4480 -970 4510 -970 {
lab=VDD}
N 4510 -740 4510 -670 {
lab=VSS}
N 4510 -670 4530 -670 {
lab=VSS}
N 4650 -820 4740 -820 {
lab=f}
N 3770 -580 3770 -510 {
lab=VDD}
N 3740 -580 3770 -580 {
lab=VDD}
N 3770 -350 3770 -280 {
lab=VSS}
N 3770 -280 3790 -280 {
lab=VSS}
N 3600 -430 3660 -430 {
lab=f}
N 3910 -430 4000 -430 {
lab=#net8}
N 4170 -580 4170 -510 {
lab=VDD}
N 4140 -580 4170 -580 {
lab=VDD}
N 4170 -350 4170 -280 {
lab=VSS}
N 4170 -280 4190 -280 {
lab=VSS}
N 4000 -430 4060 -430 {
lab=#net8}
N 4310 -430 4400 -430 {
lab=7}
N 4510 -580 4510 -510 {
lab=VDD}
N 4480 -580 4510 -580 {
lab=VDD}
N 4510 -350 4510 -280 {
lab=VSS}
N 4510 -280 4530 -280 {
lab=VSS}
N 4650 -430 4740 -430 {
lab=g}
N 3800 -180 3800 -110 {
lab=VDD}
N 3770 -180 3800 -180 {
lab=VDD}
N 3800 50 3800 120 {
lab=VSS}
N 3800 120 3820 120 {
lab=VSS}
N 3630 -30 3690 -30 {
lab=g}
N 3940 -30 4030 -30 {
lab=#net9}
N 4200 -180 4200 -110 {
lab=VDD}
N 4170 -180 4200 -180 {
lab=VDD}
N 4200 50 4200 120 {
lab=VSS}
N 4200 120 4220 120 {
lab=VSS}
N 4030 -30 4090 -30 {
lab=#net9}
N 4340 -30 4430 -30 {
lab=8}
N 4540 -180 4540 -110 {
lab=VDD}
N 4510 -180 4540 -180 {
lab=VDD}
N 4540 50 4540 120 {
lab=VSS}
N 4540 120 4560 120 {
lab=VSS}
N 4680 -30 4770 -30 {
lab=h}
N 3540 -1250 3620 -1250 {
lab=d}
N 7020 -1550 7020 -1480 {
lab=VDD}
N 6990 -1550 7020 -1550 {
lab=VDD}
N 7020 -1320 7020 -1250 {
lab=VSS}
N 7020 -1250 7040 -1250 {
lab=VSS}
N 7160 -1400 7250 -1400 {
lab=#net10}
N 6870 -1400 6910 -1400 {
lab=#net11}
N 7020 -1100 7020 -1030 {
lab=VDD}
N 6990 -1100 7020 -1100 {
lab=VDD}
N 7020 -870 7020 -800 {
lab=VSS}
N 7020 -800 7040 -800 {
lab=VSS}
N 7160 -950 7250 -950 {
lab=#net12}
N 6870 -950 6910 -950 {
lab=#net13}
N 7350 -1160 7480 -1160 {
lab=#net10}
N 7350 -1400 7350 -1160 {
lab=#net10}
N 7250 -1400 7350 -1400 {
lab=#net10}
N 7340 -1120 7480 -1120 {
lab=#net12}
N 7340 -1120 7340 -950 {
lab=#net12}
N 7250 -950 7340 -950 {
lab=#net12}
N 7680 -1150 7800 -1150 {
lab=#net14}
N 8050 -1150 8180 -1150 {
lab=ph1}
N 7910 -1340 7910 -1230 {
lab=VDD}
N 7910 -1340 7950 -1340 {
lab=VDD}
N 7910 -1070 7910 -980 {
lab=VSS}
N 7860 -980 7910 -980 {
lab=VSS}
N 7560 -1050 7560 -950 {
lab=VSS}
N 7510 -950 7560 -950 {
lab=VSS}
N 7560 -1340 7560 -1240 {
lab=VDD}
N 7560 -1340 7600 -1340 {
lab=VDD}
N 6750 -1570 6750 -1490 {
lab=VDD}
N 6700 -1570 6750 -1570 {
lab=VDD}
N 6750 -1300 6750 -1230 {
lab=VSS}
N 6750 -1230 6780 -1230 {
lab=VSS}
N 6750 -1110 6750 -1040 {
lab=VDD}
N 6750 -1110 6790 -1110 {
lab=VDD}
N 6750 -850 6750 -780 {
lab=VSS}
N 6750 -780 6790 -780 {
lab=VSS}
N 6570 -1410 6670 -1410 {
lab=1}
N 6570 -1370 6670 -1370 {
lab=b}
N 6580 -960 6670 -960 {
lab=3}
N 6580 -920 6670 -920 {
lab=d}
N 7080 -660 7080 -590 {
lab=VDD}
N 7050 -660 7080 -660 {
lab=VDD}
N 7080 -430 7080 -360 {
lab=VSS}
N 7080 -360 7100 -360 {
lab=VSS}
N 7220 -510 7310 -510 {
lab=#net15}
N 6930 -510 6970 -510 {
lab=#net16}
N 7080 -210 7080 -140 {
lab=VDD}
N 7050 -210 7080 -210 {
lab=VDD}
N 7080 20 7080 90 {
lab=VSS}
N 7080 90 7100 90 {
lab=VSS}
N 7220 -60 7310 -60 {
lab=#net17}
N 6930 -60 6970 -60 {
lab=#net18}
N 7410 -270 7540 -270 {
lab=#net15}
N 7410 -510 7410 -270 {
lab=#net15}
N 7310 -510 7410 -510 {
lab=#net15}
N 7400 -230 7540 -230 {
lab=#net17}
N 7400 -230 7400 -60 {
lab=#net17}
N 7310 -60 7400 -60 {
lab=#net17}
N 7740 -260 7860 -260 {
lab=#net19}
N 8110 -260 8240 -260 {
lab=ph2}
N 7970 -450 7970 -340 {
lab=VDD}
N 7970 -450 8010 -450 {
lab=VDD}
N 7970 -180 7970 -90 {
lab=VSS}
N 7920 -90 7970 -90 {
lab=VSS}
N 7620 -160 7620 -60 {
lab=VSS}
N 7570 -60 7620 -60 {
lab=VSS}
N 7620 -450 7620 -350 {
lab=VDD}
N 7620 -450 7660 -450 {
lab=VDD}
N 6810 -680 6810 -600 {
lab=VDD}
N 6760 -680 6810 -680 {
lab=VDD}
N 6810 -410 6810 -340 {
lab=VSS}
N 6810 -340 6840 -340 {
lab=VSS}
N 6810 -220 6810 -150 {
lab=VDD}
N 6810 -220 6850 -220 {
lab=VDD}
N 6810 40 6810 110 {
lab=VSS}
N 6810 110 6850 110 {
lab=VSS}
N 6630 -520 6730 -520 {
lab=5}
N 6630 -480 6730 -480 {
lab=f}
N 6640 -70 6730 -70 {
lab=7}
N 6640 -30 6730 -30 {
lab=h}
N 8670 -720 8790 -720 {
lab=#net20}
N 9040 -720 9170 -720 {
lab=vin2}
N 8900 -910 8900 -800 {
lab=VDD}
N 8900 -910 8940 -910 {
lab=VDD}
N 8900 -640 8900 -550 {
lab=VSS}
N 8850 -550 8900 -550 {
lab=VSS}
N 8550 -620 8550 -520 {
lab=VSS}
N 8500 -520 8550 -520 {
lab=VSS}
N 8550 -910 8550 -810 {
lab=VDD}
N 8550 -910 8590 -910 {
lab=VDD}
N 2790 -1590 2790 -1540 {
lab=VDD}
N 2790 -1590 2830 -1590 {
lab=VDD}
N 2790 -1350 2790 -1290 {
lab=VSS}
N 2790 -1290 2840 -1290 {
lab=VSS}
N 2620 -1420 2710 -1420 {
lab=vin2}
N 2620 -1420 2620 -1340 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 3190 -1450 3260 -1450 {
lab=vout}
N 8170 -1150 8410 -1150 {
lab=ph1}
N 8410 -1150 8410 -730 {
lab=ph1}
N 8410 -730 8470 -730 {
lab=ph1}
N 8240 -260 8360 -260 {
lab=ph2}
N 8360 -680 8360 -260 {
lab=ph2}
N 8360 -680 8450 -680 {
lab=ph2}
N 8450 -690 8450 -680 {
lab=ph2}
N 8450 -690 8470 -690 {
lab=ph2}
C {inverter.sym} 1790 -950 0 0 {name=X1}
C {devices/lab_wire.sym} 1580 -1390 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 -1090 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {inverter.sym} 2190 -950 0 0 {name=X2}
C {devices/lab_wire.sym} 1980 -1390 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2010 -1090 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2200 -1240 0 1 {name=l8 sig_type=std_logic lab=1}
C {inverter.sym} 2530 -950 0 0 {name=X3}
C {devices/lab_wire.sym} 2320 -1390 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2350 -1090 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2540 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {inverter.sym} 1830 -520 0 0 {name=X4}
C {devices/lab_wire.sym} 1620 -960 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -660 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {inverter.sym} 2230 -520 0 0 {name=X5}
C {devices/lab_wire.sym} 2020 -960 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -660 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {inverter.sym} 2570 -520 0 0 {name=X6}
C {devices/lab_wire.sym} 2360 -960 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -660 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {inverter.sym} 1830 -130 0 0 {name=X7}
C {devices/lab_wire.sym} 1620 -570 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -270 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {inverter.sym} 2230 -130 0 0 {name=X8}
C {devices/lab_wire.sym} 2020 -570 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -270 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {inverter.sym} 2570 -130 0 0 {name=X9}
C {devices/lab_wire.sym} 2360 -570 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -270 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {inverter.sym} 1860 270 0 0 {name=X10}
C {devices/lab_wire.sym} 1650 -170 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 130 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1520 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {inverter.sym} 2260 270 0 0 {name=X11}
C {devices/lab_wire.sym} 2050 -170 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2080 130 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2270 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {inverter.sym} 2600 270 0 0 {name=X12}
C {devices/lab_wire.sym} 2390 -170 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2420 130 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2610 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {inverter.sym} 3250 -1160 0 0 {name=X13}
C {devices/lab_wire.sym} 3040 -1600 0 0 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3070 -1300 0 1 {name=l43 sig_type=std_logic lab=VSS}
C {inverter.sym} 3920 -960 0 0 {name=X14}
C {devices/lab_wire.sym} 3710 -1400 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1100 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {inverter.sym} 4320 -960 0 0 {name=X15}
C {devices/lab_wire.sym} 4110 -1400 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4140 -1100 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4330 -1250 0 1 {name=l49 sig_type=std_logic lab=5}
C {inverter.sym} 4660 -960 0 0 {name=X16}
C {devices/lab_wire.sym} 4450 -1400 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4480 -1100 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4670 -1250 0 1 {name=l52 sig_type=std_logic lab=e}
C {inverter.sym} 3960 -530 0 0 {name=X17}
C {devices/lab_wire.sym} 3750 -970 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -670 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -820 0 0 {name=l55 sig_type=std_logic lab=e}
C {inverter.sym} 4360 -530 0 0 {name=X18}
C {devices/lab_wire.sym} 4150 -970 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -670 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -820 0 1 {name=l58 sig_type=std_logic lab=6}
C {inverter.sym} 4700 -530 0 0 {name=X19}
C {devices/lab_wire.sym} 4490 -970 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -670 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -820 0 1 {name=l61 sig_type=std_logic lab=f}
C {inverter.sym} 3960 -140 0 0 {name=X20}
C {devices/lab_wire.sym} 3750 -580 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -280 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -430 0 0 {name=l64 sig_type=std_logic lab=f}
C {inverter.sym} 4360 -140 0 0 {name=X21}
C {devices/lab_wire.sym} 4150 -580 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -280 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -430 0 1 {name=l67 sig_type=std_logic lab=7}
C {inverter.sym} 4700 -140 0 0 {name=X22}
C {devices/lab_wire.sym} 4490 -580 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -280 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -430 0 1 {name=l70 sig_type=std_logic lab=g}
C {inverter.sym} 3990 260 0 0 {name=X23}
C {devices/lab_wire.sym} 3780 -180 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3810 120 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3650 -30 0 0 {name=l73 sig_type=std_logic lab=g}
C {inverter.sym} 4390 260 0 0 {name=X24}
C {devices/lab_wire.sym} 4180 -180 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4210 120 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4400 -30 0 1 {name=l76 sig_type=std_logic lab=8}
C {inverter.sym} 4730 260 0 0 {name=X25}
C {devices/lab_wire.sym} 4520 -180 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4550 120 0 1 {name=l78 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4740 -30 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 3570 -1250 0 1 {name=l164 sig_type=std_logic lab=d}
C {inverter.sym} 7210 -1110 0 0 {name=X50}
C {devices/lab_wire.sym} 7000 -1550 0 0 {name=l44 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7030 -1250 0 1 {name=l167 sig_type=std_logic lab=VSS}
C {inverter.sym} 7210 -660 0 0 {name=X51}
C {devices/lab_wire.sym} 7000 -1100 0 0 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7030 -800 0 1 {name=l169 sig_type=std_logic lab=VSS}
C {inverter.sym} 8100 -860 0 0 {name=X52}
C {devices/lab_wire.sym} 6780 -1110 0 0 {name=l170 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6720 -1570 0 0 {name=l171 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7580 -1340 0 0 {name=l172 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7930 -1340 0 0 {name=l173 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6770 -1230 0 1 {name=l174 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6760 -780 0 1 {name=l175 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7530 -950 0 1 {name=l176 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7870 -980 0 1 {name=l177 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6620 -1410 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 6620 -1370 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 6610 -960 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 6600 -920 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 8110 -1150 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {inverter.sym} 7270 -220 0 0 {name=X53}
C {devices/lab_wire.sym} 7060 -660 0 0 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7090 -360 0 1 {name=l184 sig_type=std_logic lab=VSS}
C {inverter.sym} 7270 230 0 0 {name=X54}
C {devices/lab_wire.sym} 7060 -210 0 0 {name=l185 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7090 90 0 1 {name=l186 sig_type=std_logic lab=VSS}
C {inverter.sym} 8160 30 0 0 {name=X55}
C {devices/lab_wire.sym} 6840 -220 0 0 {name=l187 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6780 -680 0 0 {name=l188 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7640 -450 0 0 {name=l189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7990 -450 0 0 {name=l190 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6830 -340 0 1 {name=l191 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6820 110 0 1 {name=l192 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7590 -60 0 1 {name=l193 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 7930 -90 0 1 {name=l194 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 6680 -520 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 6680 -480 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 6670 -70 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 6660 -30 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 8170 -260 0 0 {name=l199 sig_type=std_logic lab=ph2}
C {inverter.sym} 9090 -430 0 0 {name=X58}
C {devices/lab_wire.sym} 8570 -910 0 0 {name=l206 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8920 -910 0 0 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 8520 -520 0 1 {name=l210 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 8860 -550 0 1 {name=l211 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 9100 -720 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2820 -1590 0 0 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2830 -1290 0 1 {name=l235 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2620 -1380 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {NOR.sym} 2440 -1330 0 0 {name=X62}
C {NOR.sym} 6400 -1280 0 0 {name=X63}
C {NOR.sym} 6400 -830 0 0 {name=X64}
C {NOR.sym} 7210 -1030 0 0 {name=X65}
C {NOR.sym} 6460 -390 0 0 {name=X66}
C {NOR.sym} 6460 60 0 0 {name=X67}
C {NOR.sym} 7270 -140 0 0 {name=X68}
C {NOR.sym} 8200 -600 0 0 {name=X71}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3260 -1450 0 0 {name=p4 lab=VOUT}
