v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 50 -80 50 -50 {
lab=#net1}
N 50 10 50 40 {
lab=#net2}
N -20 -20 30 -20 {
lab=#net3}
C {sky130_fd_pr/res_high_po_0p35.sym} 50 -20 0 0 {name=R1
W=0.35
L=1
model=res_high_po_0p35
spiceprefix=X
mult=3}
