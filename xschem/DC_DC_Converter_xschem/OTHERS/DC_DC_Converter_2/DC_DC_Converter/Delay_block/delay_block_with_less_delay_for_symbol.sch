v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1530 -1350 1530 -1280 {
lab=VDD}
N 1500 -1350 1530 -1350 {
lab=VDD}
N 1530 -1200 1530 -1130 {
lab=VSS}
N 1530 -1130 1550 -1130 {
lab=VSS}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1570 -1240 1660 -1240 {
lab=#net1}
N 1760 -1350 1760 -1280 {
lab=VDD}
N 1730 -1350 1760 -1350 {
lab=VDD}
N 1760 -1200 1760 -1130 {
lab=VSS}
N 1760 -1130 1780 -1130 {
lab=VSS}
N 1660 -1240 1720 -1240 {
lab=#net1}
N 1800 -1240 1890 -1240 {
lab=1}
N 1930 -1350 1930 -1280 {
lab=VDD}
N 1900 -1350 1930 -1350 {
lab=VDD}
N 1930 -1200 1930 -1130 {
lab=VSS}
N 1930 -1130 1950 -1130 {
lab=VSS}
N 1970 -1240 2060 -1240 {
lab=a}
N 1470 -810 1530 -810 {
lab=a}
N 1610 -810 1700 -810 {
lab=#net2}
N 1700 -810 1760 -810 {
lab=#net2}
N 1840 -810 1930 -810 {
lab=2}
N 2010 -810 2100 -810 {
lab=b}
N 1470 -420 1530 -420 {
lab=b}
N 1610 -420 1700 -420 {
lab=#net3}
N 1700 -420 1760 -420 {
lab=#net3}
N 1840 -420 1930 -420 {
lab=3}
N 2000 -420 2090 -420 {
lab=c}
N 1500 -20 1560 -20 {
lab=c}
N 1640 -20 1730 -20 {
lab=#net4}
N 1730 -20 1790 -20 {
lab=#net4}
N 1860 -20 1950 -20 {
lab=4}
N 2030 -20 2120 -20 {
lab=d}
N 2940 -1550 2940 -1480 {
lab=VDD}
N 2910 -1550 2940 -1550 {
lab=VDD}
N 2940 -1400 2940 -1330 {
lab=VSS}
N 2940 -1330 2960 -1330 {
lab=VSS}
N 2860 -1440 2900 -1440 {
lab=#net5}
N 2710 -1530 2710 -1460 {
lab=VIN}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 1670 -810 1670 -790 {
lab=#net2}
N 1630 -1240 1630 -1220 {
lab=#net1}
N 1670 -420 1670 -400 {
lab=#net3}
N 1690 -20 1690 0 {
lab=#net4}
N 2640 -1040 2730 -1040 {
lab=#net6}
N 2730 -1040 2790 -1040 {
lab=#net6}
N 2870 -1040 2960 -1040 {
lab=5}
N 3040 -1040 3130 -1040 {
lab=e}
N 2540 -610 2600 -610 {
lab=e}
N 2680 -610 2770 -610 {
lab=#net7}
N 2770 -610 2830 -610 {
lab=#net7}
N 2910 -610 3000 -610 {
lab=6}
N 3080 -610 3170 -610 {
lab=f}
N 2540 -220 2600 -220 {
lab=f}
N 2680 -220 2770 -220 {
lab=#net8}
N 2770 -220 2830 -220 {
lab=#net8}
N 2910 -220 3000 -220 {
lab=7}
N 3080 -220 3170 -220 {
lab=g}
N 2570 180 2630 180 {
lab=g}
N 2710 180 2800 180 {
lab=#net9}
N 2800 180 2860 180 {
lab=#net9}
N 2940 180 3030 180 {
lab=8}
N 3110 180 3200 180 {
lab=h}
N 2740 -610 2740 -590 {
lab=#net7}
N 2700 -1040 2700 -1020 {
lab=#net6}
N 2740 -220 2740 -200 {
lab=#net8}
N 2760 180 2760 200 {
lab=#net9}
N 2480 -1040 2560 -1040 {
lab=d}
N 4040 -1060 4170 -1060 {
lab=#net10}
N 4040 -1300 4040 -1060 {
lab=#net10}
N 3940 -1300 4040 -1300 {
lab=#net10}
N 4030 -1020 4170 -1020 {
lab=#net12}
N 4030 -1020 4030 -850 {
lab=#net12}
N 3940 -850 4030 -850 {
lab=#net12}
N 4320 -1040 4440 -1040 {
lab=#net14}
N 4560 -1040 4690 -1040 {
lab=ph1}
N 3500 -1320 3600 -1320 {
lab=1}
N 3500 -1280 3600 -1280 {
lab=b}
N 3510 -870 3600 -870 {
lab=3}
N 3510 -830 3600 -830 {
lab=d}
N 4100 -170 4230 -170 {
lab=#net15}
N 4100 -410 4100 -170 {
lab=#net15}
N 4000 -410 4100 -410 {
lab=#net15}
N 4090 -130 4230 -130 {
lab=#net17}
N 4090 -130 4090 40 {
lab=#net17}
N 4000 40 4090 40 {
lab=#net17}
N 4380 -150 4500 -150 {
lab=#net19}
N 4620 -150 4750 -150 {
lab=ph2}
N 3560 -430 3660 -430 {
lab=5}
N 3560 -390 3660 -390 {
lab=f}
N 3570 20 3660 20 {
lab=7}
N 3570 60 3660 60 {
lab=h}
N 5130 -600 5250 -600 {
lab=#net20}
N 5330 -600 5460 -600 {
lab=vin2}
N 5290 -750 5290 -640 {
lab=VDD}
N 5290 -750 5330 -750 {
lab=VDD}
N 5290 -560 5290 -470 {
lab=VSS}
N 5240 -470 5290 -470 {
lab=VSS}
N 2760 -1550 2760 -1500 {
lab=VDD}
N 2760 -1550 2800 -1550 {
lab=VDD}
N 2760 -1380 2760 -1320 {
lab=VSS}
N 2760 -1320 2810 -1320 {
lab=VSS}
N 2620 -1420 2710 -1420 {
lab=vin2}
N 2620 -1420 2620 -1340 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 2980 -1440 3050 -1440 {
lab=vout}
N 4680 -1040 4920 -1040 {
lab=ph1}
N 4920 -1040 4920 -620 {
lab=ph1}
N 4920 -620 4980 -620 {
lab=ph1}
N 4750 -150 4870 -150 {
lab=ph2}
N 4870 -570 4870 -150 {
lab=ph2}
N 4870 -570 4960 -570 {
lab=ph2}
N 4960 -580 4960 -570 {
lab=ph2}
N 4960 -580 4980 -580 {
lab=ph2}
N 3650 -1410 3650 -1360 {
lab=VDD}
N 3650 -1410 3690 -1410 {
lab=VDD}
N 3650 -1240 3650 -1180 {
lab=VSS}
N 3650 -1180 3700 -1180 {
lab=VSS}
N 3650 -960 3650 -910 {
lab=VDD}
N 3650 -960 3690 -960 {
lab=VDD}
N 3650 -790 3650 -730 {
lab=VSS}
N 3650 -730 3700 -730 {
lab=VSS}
N 3710 -520 3710 -470 {
lab=VDD}
N 3710 -520 3750 -520 {
lab=VDD}
N 3710 -350 3710 -290 {
lab=VSS}
N 3710 -290 3760 -290 {
lab=VSS}
N 3710 -70 3710 -20 {
lab=VDD}
N 3710 -70 3750 -70 {
lab=VDD}
N 3710 100 3710 160 {
lab=VSS}
N 3710 160 3760 160 {
lab=VSS}
N 4280 -260 4280 -210 {
lab=VDD}
N 4280 -260 4320 -260 {
lab=VDD}
N 4280 -90 4280 -30 {
lab=VSS}
N 4280 -30 4330 -30 {
lab=VSS}
N 4220 -1150 4220 -1100 {
lab=VDD}
N 4220 -1150 4260 -1150 {
lab=VDD}
N 4220 -980 4220 -920 {
lab=VSS}
N 4220 -920 4270 -920 {
lab=VSS}
N 5030 -710 5030 -660 {
lab=VDD}
N 5030 -710 5070 -710 {
lab=VDD}
N 5030 -540 5030 -480 {
lab=VSS}
N 5030 -480 5080 -480 {
lab=VSS}
N 1630 -1160 1630 -1090 {
lab=VSS}
N 1630 -1090 1650 -1090 {
lab=VSS}
N 1570 -920 1570 -850 {
lab=VDD}
N 1540 -920 1570 -920 {
lab=VDD}
N 1670 -730 1670 -660 {
lab=VSS}
N 1670 -660 1690 -660 {
lab=VSS}
N 1800 -920 1800 -850 {
lab=VDD}
N 1770 -920 1800 -920 {
lab=VDD}
N 1800 -770 1800 -700 {
lab=VSS}
N 1800 -700 1820 -700 {
lab=VSS}
N 1970 -920 1970 -850 {
lab=VDD}
N 1940 -920 1970 -920 {
lab=VDD}
N 1970 -770 1970 -700 {
lab=VSS}
N 1970 -700 1990 -700 {
lab=VSS}
N 1570 -530 1570 -460 {
lab=VDD}
N 1540 -530 1570 -530 {
lab=VDD}
N 1570 -380 1570 -310 {
lab=VSS}
N 1570 -310 1590 -310 {
lab=VSS}
N 1800 -530 1800 -460 {
lab=VDD}
N 1770 -530 1800 -530 {
lab=VDD}
N 1800 -380 1800 -310 {
lab=VSS}
N 1800 -310 1820 -310 {
lab=VSS}
N 1970 -530 1970 -460 {
lab=VDD}
N 1940 -530 1970 -530 {
lab=VDD}
N 1970 -380 1970 -310 {
lab=VSS}
N 1970 -310 1990 -310 {
lab=VSS}
N 1990 -130 1990 -60 {
lab=VDD}
N 1960 -130 1990 -130 {
lab=VDD}
N 1990 20 1990 90 {
lab=VSS}
N 1990 90 2010 90 {
lab=VSS}
N 1830 -130 1830 -60 {
lab=VDD}
N 1800 -130 1830 -130 {
lab=VDD}
N 1830 20 1830 90 {
lab=VSS}
N 1830 90 1850 90 {
lab=VSS}
N 1600 -130 1600 -60 {
lab=VDD}
N 1570 -130 1600 -130 {
lab=VDD}
N 1600 20 1600 90 {
lab=VSS}
N 1600 90 1620 90 {
lab=VSS}
N 1670 -340 1670 -270 {
lab=VSS}
N 1670 -270 1690 -270 {
lab=VSS}
N 1690 60 1690 130 {
lab=VSS}
N 1690 130 1710 130 {
lab=VSS}
N 3830 -1410 3830 -1340 {
lab=VDD}
N 3800 -1410 3830 -1410 {
lab=VDD}
N 3830 -1260 3830 -1190 {
lab=VSS}
N 3830 -1190 3850 -1190 {
lab=VSS}
N 3750 -1300 3790 -1300 {
lab=#net5}
N 3870 -1300 3940 -1300 {
lab=vout}
N 3830 -960 3830 -890 {
lab=VDD}
N 3800 -960 3830 -960 {
lab=VDD}
N 3830 -810 3830 -740 {
lab=VSS}
N 3830 -740 3850 -740 {
lab=VSS}
N 3750 -850 3790 -850 {
lab=#net5}
N 3870 -850 3940 -850 {
lab=vout}
N 3890 -520 3890 -450 {
lab=VDD}
N 3860 -520 3890 -520 {
lab=VDD}
N 3890 -370 3890 -300 {
lab=VSS}
N 3890 -300 3910 -300 {
lab=VSS}
N 3810 -410 3850 -410 {
lab=#net5}
N 3930 -410 4000 -410 {
lab=vout}
N 3890 -70 3890 0 {
lab=VDD}
N 3860 -70 3890 -70 {
lab=VDD}
N 3890 80 3890 150 {
lab=VSS}
N 3890 150 3910 150 {
lab=VSS}
N 3810 40 3850 40 {
lab=#net5}
N 3930 40 4000 40 {
lab=vout}
N 4520 -1150 4520 -1080 {
lab=VDD}
N 4490 -1150 4520 -1150 {
lab=VDD}
N 4520 -1000 4520 -930 {
lab=VSS}
N 4520 -930 4540 -930 {
lab=VSS}
N 4440 -1040 4480 -1040 {
lab=#net5}
N 4580 -260 4580 -190 {
lab=VDD}
N 4550 -260 4580 -260 {
lab=VDD}
N 4580 -110 4580 -40 {
lab=VSS}
N 4580 -40 4600 -40 {
lab=VSS}
N 4500 -150 4540 -150 {
lab=#net5}
N 3000 -1150 3000 -1080 {
lab=VDD}
N 2970 -1150 3000 -1150 {
lab=VDD}
N 3000 -1000 3000 -930 {
lab=VSS}
N 3000 -930 3020 -930 {
lab=VSS}
N 3040 -720 3040 -650 {
lab=VDD}
N 3010 -720 3040 -720 {
lab=VDD}
N 3040 -570 3040 -500 {
lab=VSS}
N 3040 -500 3060 -500 {
lab=VSS}
N 3040 -330 3040 -260 {
lab=VDD}
N 3010 -330 3040 -330 {
lab=VDD}
N 3040 -180 3040 -110 {
lab=VSS}
N 3040 -110 3060 -110 {
lab=VSS}
N 3070 70 3070 140 {
lab=VDD}
N 3040 70 3070 70 {
lab=VDD}
N 3070 220 3070 290 {
lab=VSS}
N 3070 290 3090 290 {
lab=VSS}
N 2830 -1150 2830 -1080 {
lab=VDD}
N 2800 -1150 2830 -1150 {
lab=VDD}
N 2830 -1000 2830 -930 {
lab=VSS}
N 2830 -930 2850 -930 {
lab=VSS}
N 2870 -720 2870 -650 {
lab=VDD}
N 2840 -720 2870 -720 {
lab=VDD}
N 2870 -570 2870 -500 {
lab=VSS}
N 2870 -500 2890 -500 {
lab=VSS}
N 2870 -330 2870 -260 {
lab=VDD}
N 2840 -330 2870 -330 {
lab=VDD}
N 2870 -180 2870 -110 {
lab=VSS}
N 2870 -110 2890 -110 {
lab=VSS}
N 2900 70 2900 140 {
lab=VDD}
N 2870 70 2900 70 {
lab=VDD}
N 2900 220 2900 290 {
lab=VSS}
N 2900 290 2920 290 {
lab=VSS}
N 2760 260 2760 330 {
lab=VSS}
N 2760 330 2780 330 {
lab=VSS}
N 2740 -140 2740 -70 {
lab=VSS}
N 2740 -70 2760 -70 {
lab=VSS}
N 2740 -530 2740 -460 {
lab=VSS}
N 2740 -460 2760 -460 {
lab=VSS}
N 2700 -960 2700 -890 {
lab=VSS}
N 2700 -890 2720 -890 {
lab=VSS}
N 2600 -1150 2600 -1080 {
lab=VDD}
N 2570 -1150 2600 -1150 {
lab=VDD}
N 2600 -1000 2600 -930 {
lab=VSS}
N 2600 -930 2620 -930 {
lab=VSS}
N 2640 -720 2640 -650 {
lab=VDD}
N 2610 -720 2640 -720 {
lab=VDD}
N 2640 -570 2640 -500 {
lab=VSS}
N 2640 -500 2660 -500 {
lab=VSS}
N 2640 -330 2640 -260 {
lab=VDD}
N 2610 -330 2640 -330 {
lab=VDD}
N 2640 -180 2640 -110 {
lab=VSS}
N 2640 -110 2660 -110 {
lab=VSS}
N 2670 70 2670 140 {
lab=VDD}
N 2640 70 2670 70 {
lab=VDD}
N 2670 220 2670 290 {
lab=VSS}
N 2670 290 2690 290 {
lab=VSS}
N 1570 -770 1570 -700 {
lab=VSS}
N 1570 -700 1590 -700 {
lab=VSS}
C {devices/lab_wire.sym} 1510 -1350 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1540 -1130 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1740 -1350 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1770 -1130 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1860 -1240 0 1 {name=l8 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 1910 -1350 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1940 -1130 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2030 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {devices/lab_wire.sym} 1490 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {devices/lab_wire.sym} 1900 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {devices/lab_wire.sym} 2070 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 1490 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 1900 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 2060 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {devices/lab_wire.sym} 1520 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {devices/lab_wire.sym} 1900 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {devices/lab_wire.sym} 2090 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 2920 -1550 0 0 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2950 -1330 0 1 {name=l43 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1670 -760 0 0 {name=C1
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 1630 -1190 0 0 {name=C2
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 1670 -370 0 0 {name=C3
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 1690 30 0 0 {name=C4
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 2930 -1040 0 1 {name=l49 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 3100 -1040 0 1 {name=l52 sig_type=std_logic lab=e}
C {devices/lab_wire.sym} 2560 -610 0 0 {name=l55 sig_type=std_logic lab=e}
C {devices/lab_wire.sym} 2970 -610 0 1 {name=l58 sig_type=std_logic lab=6}
C {devices/lab_wire.sym} 3140 -610 0 1 {name=l61 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 2560 -220 0 0 {name=l64 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 2970 -220 0 1 {name=l67 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 3140 -220 0 1 {name=l70 sig_type=std_logic lab=g}
C {devices/lab_wire.sym} 2590 180 0 0 {name=l73 sig_type=std_logic lab=g}
C {devices/lab_wire.sym} 3000 180 0 1 {name=l76 sig_type=std_logic lab=8}
C {devices/lab_wire.sym} 3170 180 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/capa.sym} 2740 -560 0 0 {name=C5
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 2700 -990 0 0 {name=C6
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 2740 -170 0 0 {name=C7
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 2760 230 0 0 {name=C8
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 2510 -1040 0 1 {name=l164 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 3550 -1320 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 3550 -1280 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 3540 -870 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 3530 -830 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 4620 -1040 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {devices/lab_wire.sym} 3610 -430 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 3610 -390 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 3600 20 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 3590 60 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 4680 -150 0 0 {name=l199 sig_type=std_logic lab=ph2}
C {devices/lab_wire.sym} 5310 -750 0 0 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5250 -470 0 1 {name=l211 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5390 -600 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2790 -1550 0 0 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2800 -1320 0 1 {name=l235 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2620 -1360 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3050 -1440 0 0 {name=p4 lab=VOUT}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 2690 -1370 0 0 {name=X_NOR1}
C {devices/lab_wire.sym} 3680 -1410 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3690 -1180 0 1 {name=l46 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 3580 -1230 0 0 {name=X_NOR2}
C {devices/lab_wire.sym} 3680 -960 0 0 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3690 -730 0 1 {name=l85 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 3580 -780 0 0 {name=X_NOR3}
C {devices/lab_wire.sym} 3740 -520 0 0 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3750 -290 0 1 {name=l87 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 3640 -340 0 0 {name=X_NOR4}
C {devices/lab_wire.sym} 3740 -70 0 0 {name=l88 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3750 160 0 1 {name=l89 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 3640 110 0 0 {name=X_NOR5}
C {devices/lab_wire.sym} 4310 -260 0 0 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4320 -30 0 1 {name=l91 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 4210 -80 0 0 {name=X_NOR6}
C {devices/lab_wire.sym} 4250 -1150 0 0 {name=l92 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4260 -920 0 1 {name=l93 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 4150 -970 0 0 {name=X_NOR7}
C {devices/lab_wire.sym} 5060 -710 0 0 {name=l94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5070 -480 0 1 {name=l95 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/NOR_GATE/NOR.sym} 4960 -530 0 0 {name=X_NOR8}
C {DC_DC_Converter/Inverter/Inverter.sym} 1460 -1220 0 0 {name=X26}
C {DC_DC_Converter/Inverter/Inverter.sym} 1690 -1220 0 0 {name=X1}
C {DC_DC_Converter/Inverter/Inverter.sym} 1860 -1220 0 0 {name=X2}
C {devices/lab_wire.sym} 1630 -1100 0 1 {name=l24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1550 -920 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 -660 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1500 -790 0 0 {name=X3}
C {devices/lab_wire.sym} 1780 -920 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1810 -700 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1730 -790 0 0 {name=X4}
C {devices/lab_wire.sym} 1950 -920 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1980 -700 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1900 -790 0 0 {name=X5}
C {devices/lab_wire.sym} 1550 -530 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1580 -310 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1500 -400 0 0 {name=X6}
C {devices/lab_wire.sym} 1780 -530 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1810 -310 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1730 -400 0 0 {name=X7}
C {devices/lab_wire.sym} 1950 -530 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1980 -310 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1900 -400 0 0 {name=X8}
C {devices/lab_wire.sym} 1970 -130 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1990 70 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1920 0 0 0 {name=X9}
C {devices/lab_wire.sym} 1810 -130 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1840 90 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1760 0 0 0 {name=X10}
C {devices/lab_wire.sym} 1580 -130 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 90 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 1530 0 0 0 {name=X11}
C {devices/lab_wire.sym} 1680 -270 0 1 {name=l14 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1700 130 0 1 {name=l34 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2870 -1420 0 0 {name=X12}
C {devices/lab_wire.sym} 3810 -1410 0 0 {name=l41 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3840 -1190 0 1 {name=l44 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 3760 -1280 0 0 {name=X13}
C {devices/lab_wire.sym} 3810 -960 0 0 {name=l96 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3840 -740 0 1 {name=l97 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 3760 -830 0 0 {name=X27}
C {devices/lab_wire.sym} 3870 -520 0 0 {name=l98 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -300 0 1 {name=l99 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 3820 -390 0 0 {name=X28}
C {devices/lab_wire.sym} 3870 -70 0 0 {name=l100 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 150 0 1 {name=l101 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 3820 60 0 0 {name=X29}
C {devices/lab_wire.sym} 4500 -1150 0 0 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4530 -930 0 1 {name=l103 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 4450 -1020 0 0 {name=X30}
C {devices/lab_wire.sym} 4560 -260 0 0 {name=l104 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4590 -40 0 1 {name=l105 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 4510 -130 0 0 {name=X31}
C {DC_DC_Converter/Inverter/Inverter.sym} 5220 -580 0 0 {name=X32}
C {devices/lab_wire.sym} 2980 -1150 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3010 -930 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2930 -1020 0 0 {name=X14}
C {devices/lab_wire.sym} 3020 -720 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3050 -500 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2970 -590 0 0 {name=X15}
C {devices/lab_wire.sym} 3020 -330 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3050 -110 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2970 -200 0 0 {name=X16}
C {devices/lab_wire.sym} 3050 70 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3080 290 0 1 {name=l78 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 3000 200 0 0 {name=X19}
C {devices/lab_wire.sym} 2810 -1150 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2840 -930 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2760 -1020 0 0 {name=X18}
C {devices/lab_wire.sym} 2850 -720 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2880 -500 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2800 -590 0 0 {name=X21}
C {devices/lab_wire.sym} 2850 -330 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2880 -110 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2800 -200 0 0 {name=X22}
C {devices/lab_wire.sym} 2880 70 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2910 290 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2830 200 0 0 {name=X24}
C {devices/lab_wire.sym} 2770 330 0 1 {name=l80 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2750 -70 0 1 {name=l81 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2750 -460 0 1 {name=l82 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2710 -890 0 1 {name=l83 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -1150 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2610 -930 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2530 -1020 0 0 {name=X17}
C {devices/lab_wire.sym} 2620 -720 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2650 -500 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2570 -590 0 0 {name=X20}
C {devices/lab_wire.sym} 2620 -330 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2650 -110 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2570 -200 0 0 {name=X23}
C {devices/lab_wire.sym} 2650 70 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2680 290 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Inverter/Inverter.sym} 2600 200 0 0 {name=X25}
C {devices/lab_wire.sym} 1580 -700 0 1 {name=l106 sig_type=std_logic lab=VSS}
