v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1600 -1390 1600 -1320 {
lab=VDD}
N 1570 -1390 1600 -1390 {
lab=VDD}
N 1600 -1160 1600 -1090 {
lab=VSS}
N 1600 -1090 1620 -1090 {
lab=VSS}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1740 -1240 1830 -1240 {
lab=#net1}
N 2000 -1390 2000 -1320 {
lab=VDD}
N 1970 -1390 2000 -1390 {
lab=VDD}
N 2000 -1160 2000 -1090 {
lab=VSS}
N 2000 -1090 2020 -1090 {
lab=VSS}
N 1830 -1240 1890 -1240 {
lab=#net1}
N 2140 -1240 2230 -1240 {
lab=1}
N 2340 -1390 2340 -1320 {
lab=VDD}
N 2310 -1390 2340 -1390 {
lab=VDD}
N 2340 -1160 2340 -1090 {
lab=VSS}
N 2340 -1090 2360 -1090 {
lab=VSS}
N 2480 -1240 2570 -1240 {
lab=a}
N 1640 -960 1640 -890 {
lab=VDD}
N 1610 -960 1640 -960 {
lab=VDD}
N 1640 -730 1640 -660 {
lab=VSS}
N 1640 -660 1660 -660 {
lab=VSS}
N 1470 -810 1530 -810 {
lab=a}
N 1780 -810 1870 -810 {
lab=#net2}
N 2040 -960 2040 -890 {
lab=VDD}
N 2010 -960 2040 -960 {
lab=VDD}
N 2040 -730 2040 -660 {
lab=VSS}
N 2040 -660 2060 -660 {
lab=VSS}
N 1870 -810 1930 -810 {
lab=#net2}
N 2180 -810 2270 -810 {
lab=2}
N 2380 -960 2380 -890 {
lab=VDD}
N 2350 -960 2380 -960 {
lab=VDD}
N 2380 -730 2380 -660 {
lab=VSS}
N 2380 -660 2400 -660 {
lab=VSS}
N 2520 -810 2610 -810 {
lab=b}
N 1640 -570 1640 -500 {
lab=VDD}
N 1610 -570 1640 -570 {
lab=VDD}
N 1640 -340 1640 -270 {
lab=VSS}
N 1640 -270 1660 -270 {
lab=VSS}
N 1470 -420 1530 -420 {
lab=b}
N 1780 -420 1870 -420 {
lab=#net3}
N 2040 -570 2040 -500 {
lab=VDD}
N 2010 -570 2040 -570 {
lab=VDD}
N 2040 -340 2040 -270 {
lab=VSS}
N 2040 -270 2060 -270 {
lab=VSS}
N 1870 -420 1930 -420 {
lab=#net3}
N 2180 -420 2270 -420 {
lab=3}
N 2380 -570 2380 -500 {
lab=VDD}
N 2350 -570 2380 -570 {
lab=VDD}
N 2380 -340 2380 -270 {
lab=VSS}
N 2380 -270 2400 -270 {
lab=VSS}
N 2520 -420 2610 -420 {
lab=c}
N 1670 -170 1670 -100 {
lab=VDD}
N 1640 -170 1670 -170 {
lab=VDD}
N 1670 60 1670 130 {
lab=VSS}
N 1670 130 1690 130 {
lab=VSS}
N 1500 -20 1560 -20 {
lab=c}
N 1810 -20 1900 -20 {
lab=#net4}
N 2070 -170 2070 -100 {
lab=VDD}
N 2040 -170 2070 -170 {
lab=VDD}
N 2070 60 2070 130 {
lab=VSS}
N 2070 130 2090 130 {
lab=VSS}
N 1900 -20 1960 -20 {
lab=#net4}
N 2210 -20 2300 -20 {
lab=4}
N 2410 -170 2410 -100 {
lab=VDD}
N 2380 -170 2410 -170 {
lab=VDD}
N 2410 60 2410 130 {
lab=VSS}
N 2410 130 2430 130 {
lab=VSS}
N 2550 -20 2640 -20 {
lab=d}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 3730 -1400 3730 -1330 {
lab=VDD}
N 3700 -1400 3730 -1400 {
lab=VDD}
N 3730 -1170 3730 -1100 {
lab=VSS}
N 3730 -1100 3750 -1100 {
lab=VSS}
N 3870 -1250 3960 -1250 {
lab=#net6}
N 4130 -1400 4130 -1330 {
lab=VDD}
N 4100 -1400 4130 -1400 {
lab=VDD}
N 4130 -1170 4130 -1100 {
lab=VSS}
N 4130 -1100 4150 -1100 {
lab=VSS}
N 3960 -1250 4020 -1250 {
lab=#net6}
N 4270 -1250 4360 -1250 {
lab=5}
N 4470 -1400 4470 -1330 {
lab=VDD}
N 4440 -1400 4470 -1400 {
lab=VDD}
N 4470 -1170 4470 -1100 {
lab=VSS}
N 4470 -1100 4490 -1100 {
lab=VSS}
N 4610 -1250 4700 -1250 {
lab=e}
N 3770 -970 3770 -900 {
lab=VDD}
N 3740 -970 3770 -970 {
lab=VDD}
N 3770 -740 3770 -670 {
lab=VSS}
N 3770 -670 3790 -670 {
lab=VSS}
N 3600 -820 3660 -820 {
lab=e}
N 3910 -820 4000 -820 {
lab=#net7}
N 4170 -970 4170 -900 {
lab=VDD}
N 4140 -970 4170 -970 {
lab=VDD}
N 4170 -740 4170 -670 {
lab=VSS}
N 4170 -670 4190 -670 {
lab=VSS}
N 4000 -820 4060 -820 {
lab=#net7}
N 4310 -820 4400 -820 {
lab=6}
N 4510 -970 4510 -900 {
lab=VDD}
N 4480 -970 4510 -970 {
lab=VDD}
N 4510 -740 4510 -670 {
lab=VSS}
N 4510 -670 4530 -670 {
lab=VSS}
N 4650 -820 4740 -820 {
lab=f}
N 3770 -580 3770 -510 {
lab=VDD}
N 3740 -580 3770 -580 {
lab=VDD}
N 3770 -350 3770 -280 {
lab=VSS}
N 3770 -280 3790 -280 {
lab=VSS}
N 3600 -430 3660 -430 {
lab=f}
N 3910 -430 4000 -430 {
lab=#net8}
N 4170 -580 4170 -510 {
lab=VDD}
N 4140 -580 4170 -580 {
lab=VDD}
N 4170 -350 4170 -280 {
lab=VSS}
N 4170 -280 4190 -280 {
lab=VSS}
N 4000 -430 4060 -430 {
lab=#net8}
N 4310 -430 4400 -430 {
lab=7}
N 4510 -580 4510 -510 {
lab=VDD}
N 4480 -580 4510 -580 {
lab=VDD}
N 4510 -350 4510 -280 {
lab=VSS}
N 4510 -280 4530 -280 {
lab=VSS}
N 4650 -430 4740 -430 {
lab=g}
N 3800 -180 3800 -110 {
lab=VDD}
N 3770 -180 3800 -180 {
lab=VDD}
N 3800 50 3800 120 {
lab=VSS}
N 3800 120 3820 120 {
lab=VSS}
N 3630 -30 3690 -30 {
lab=g}
N 3940 -30 4030 -30 {
lab=#net9}
N 4200 -180 4200 -110 {
lab=VDD}
N 4170 -180 4200 -180 {
lab=VDD}
N 4200 50 4200 120 {
lab=VSS}
N 4200 120 4220 120 {
lab=VSS}
N 4030 -30 4090 -30 {
lab=#net9}
N 4340 -30 4430 -30 {
lab=8}
N 4540 -180 4540 -110 {
lab=VDD}
N 4510 -180 4540 -180 {
lab=VDD}
N 4540 50 4540 120 {
lab=VSS}
N 4540 120 4560 120 {
lab=VSS}
N 4680 -30 4770 -30 {
lab=h}
N 3540 -1250 3620 -1250 {
lab=d}
N 5990 -1320 6080 -1320 {
lab=#net10}
N 5990 -870 6080 -870 {
lab=#net12}
N 6180 -1080 6310 -1080 {
lab=#net10}
N 6180 -1320 6180 -1080 {
lab=#net10}
N 6080 -1320 6180 -1320 {
lab=#net10}
N 6170 -1040 6310 -1040 {
lab=#net12}
N 6170 -1040 6170 -870 {
lab=#net12}
N 6080 -870 6170 -870 {
lab=#net12}
N 6590 -1060 6720 -1060 {
lab=ph1}
N 5700 -1340 5800 -1340 {
lab=1}
N 5700 -1300 5800 -1300 {
lab=b}
N 5620 -890 5710 -890 {
lab=3}
N 5620 -850 5710 -850 {
lab=d}
N 5960 -430 6050 -430 {
lab=#net15}
N 5960 20 6050 20 {
lab=#net17}
N 6150 -190 6280 -190 {
lab=#net15}
N 6150 -430 6150 -190 {
lab=#net15}
N 6050 -430 6150 -430 {
lab=#net15}
N 6140 -150 6280 -150 {
lab=#net17}
N 6140 -150 6140 20 {
lab=#net17}
N 6050 20 6140 20 {
lab=#net17}
N 6650 -170 6780 -170 {
lab=ph2}
N 5580 -450 5680 -450 {
lab=5}
N 5580 -410 5680 -410 {
lab=f}
N 5500 0 5590 0 {
lab=7}
N 5500 40 5590 40 {
lab=h}
N 7290 -620 7420 -620 {
lab=vin2}
N 2620 -1490 2710 -1490 {
lab=vin2}
N 2620 -1490 2620 -1410 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 3090 -1510 3160 -1510 {
lab=VOUT}
N 6710 -1060 6950 -1060 {
lab=ph1}
N 6950 -1060 6950 -640 {
lab=ph1}
N 6950 -640 7010 -640 {
lab=ph1}
N 6780 -170 6900 -170 {
lab=ph2}
N 6900 -590 6900 -170 {
lab=ph2}
N 5950 -1320 5990 -1320 {
lab=#net5}
N 5850 -1430 5850 -1380 {
lab=VDD}
N 5850 -1430 5890 -1430 {
lab=VDD}
N 5850 -1260 5850 -1200 {
lab=VSS}
N 5850 -1200 5900 -1200 {
lab=VSS}
N 1870 -20 1870 0 {}
N 1870 60 1870 130 {}
N 1860 -420 1860 -400 {}
N 1860 -340 1860 -270 {}
N 1850 -810 1850 -790 {}
N 1850 -730 1850 -660 {}
N 1830 -1240 1830 -1220 {}
N 1830 -1160 1830 -1090 {}
N 4020 -30 4020 -10 {}
N 4020 50 4020 120 {}
N 4010 -430 4010 -410 {}
N 4010 -350 4010 -280 {}
N 4000 -820 4000 -800 {}
N 4000 -740 4000 -670 {}
N 3980 -1250 3980 -1230 {}
N 3980 -1170 3980 -1100 {}
N 5900 -870 5990 -870 {
lab=#net10}
N 5860 -870 5900 -870 {
lab=#net5}
N 5760 -980 5760 -930 {
lab=VDD}
N 5760 -980 5800 -980 {
lab=VDD}
N 5760 -810 5760 -750 {
lab=VSS}
N 5760 -750 5810 -750 {
lab=VSS}
N 5870 -430 5960 -430 {
lab=#net10}
N 5830 -430 5870 -430 {
lab=#net5}
N 5730 -540 5730 -490 {
lab=VDD}
N 5730 -540 5770 -540 {
lab=VDD}
N 5730 -370 5730 -310 {
lab=VSS}
N 5730 -310 5780 -310 {
lab=VSS}
N 5870 20 5960 20 {
lab=#net15}
N 5780 20 5870 20 {
lab=#net10}
N 5740 20 5780 20 {
lab=#net5}
N 5640 -90 5640 -40 {
lab=VDD}
N 5640 -90 5680 -90 {
lab=VDD}
N 5640 80 5640 140 {
lab=VSS}
N 5640 140 5690 140 {
lab=VSS}
N 6500 -1060 6590 -1060 {
lab=#net10}
N 6460 -1060 6500 -1060 {
lab=#net5}
N 6360 -1170 6360 -1120 {
lab=VDD}
N 6360 -1170 6400 -1170 {
lab=VDD}
N 6360 -1000 6360 -940 {
lab=VSS}
N 6360 -940 6410 -940 {
lab=VSS}
N 6560 -170 6650 -170 {
lab=#net15}
N 6470 -170 6560 -170 {
lab=#net10}
N 6430 -170 6470 -170 {
lab=#net5}
N 6330 -280 6330 -230 {
lab=VDD}
N 6330 -280 6370 -280 {
lab=VDD}
N 6330 -110 6330 -50 {
lab=VSS}
N 6330 -50 6380 -50 {
lab=VSS}
N 7200 -620 7290 -620 {
lab=#net10}
N 7160 -620 7200 -620 {
lab=#net5}
N 7060 -730 7060 -680 {
lab=VDD}
N 7060 -730 7100 -730 {
lab=VDD}
N 7060 -560 7060 -500 {
lab=VSS}
N 7060 -500 7110 -500 {
lab=VSS}
N 6900 -600 7010 -600 {}
N 6900 -600 6900 -590 {}
N 3000 -1510 3090 -1510 {
lab=#net10}
N 2710 -1530 2810 -1530 {
lab=1}
N 2710 -1490 2810 -1490 {
lab=b}
N 2960 -1510 3000 -1510 {
lab=#net5}
N 2860 -1620 2860 -1570 {
lab=VDD}
N 2860 -1620 2900 -1620 {
lab=VDD}
N 2860 -1450 2860 -1390 {
lab=VSS}
N 2860 -1390 2910 -1390 {
lab=VSS}
C {inverter_delay.sym} 1790 -950 0 0 {name=X1}
C {devices/lab_wire.sym} 1580 -1390 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1610 -1090 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 2190 -950 0 0 {name=X2}
C {devices/lab_wire.sym} 1980 -1390 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2010 -1090 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2200 -1240 0 1 {name=l8 sig_type=std_logic lab=1}
C {inverter_delay.sym} 2530 -950 0 0 {name=X3}
C {devices/lab_wire.sym} 2320 -1390 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2350 -1090 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2540 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {inverter_delay.sym} 1830 -520 0 0 {name=X4}
C {devices/lab_wire.sym} 1620 -960 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -660 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {inverter_delay.sym} 2230 -520 0 0 {name=X5}
C {devices/lab_wire.sym} 2020 -960 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -660 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {inverter_delay.sym} 2570 -520 0 0 {name=X6}
C {devices/lab_wire.sym} 2360 -960 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -660 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {inverter_delay.sym} 1830 -130 0 0 {name=X7}
C {devices/lab_wire.sym} 1620 -570 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1650 -270 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1490 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {inverter_delay.sym} 2230 -130 0 0 {name=X8}
C {devices/lab_wire.sym} 2020 -570 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2050 -270 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2240 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {inverter_delay.sym} 2570 -130 0 0 {name=X9}
C {devices/lab_wire.sym} 2360 -570 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2390 -270 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {inverter_delay.sym} 1860 270 0 0 {name=X10}
C {devices/lab_wire.sym} 1650 -170 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1680 130 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1520 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {inverter_delay.sym} 2260 270 0 0 {name=X11}
C {devices/lab_wire.sym} 2050 -170 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2080 130 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2270 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {inverter_delay.sym} 2600 270 0 0 {name=X12}
C {devices/lab_wire.sym} 2390 -170 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2420 130 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2610 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {inverter_delay.sym} 3920 -960 0 0 {name=X14}
C {devices/lab_wire.sym} 3710 -1400 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3740 -1100 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {inverter_delay.sym} 4320 -960 0 0 {name=X15}
C {devices/lab_wire.sym} 4110 -1400 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4140 -1100 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4330 -1250 0 1 {name=l49 sig_type=std_logic lab=5}
C {inverter_delay.sym} 4660 -960 0 0 {name=X16}
C {devices/lab_wire.sym} 4450 -1400 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4480 -1100 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4670 -1250 0 1 {name=l52 sig_type=std_logic lab=e}
C {inverter_delay.sym} 3960 -530 0 0 {name=X17}
C {devices/lab_wire.sym} 3750 -970 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -670 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -820 0 0 {name=l55 sig_type=std_logic lab=e}
C {inverter_delay.sym} 4360 -530 0 0 {name=X18}
C {devices/lab_wire.sym} 4150 -970 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -670 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -820 0 1 {name=l58 sig_type=std_logic lab=6}
C {inverter_delay.sym} 4700 -530 0 0 {name=X19}
C {devices/lab_wire.sym} 4490 -970 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -670 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -820 0 1 {name=l61 sig_type=std_logic lab=f}
C {inverter_delay.sym} 3960 -140 0 0 {name=X20}
C {devices/lab_wire.sym} 3750 -580 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3780 -280 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3620 -430 0 0 {name=l64 sig_type=std_logic lab=f}
C {inverter_delay.sym} 4360 -140 0 0 {name=X21}
C {devices/lab_wire.sym} 4150 -580 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4180 -280 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4370 -430 0 1 {name=l67 sig_type=std_logic lab=7}
C {inverter_delay.sym} 4700 -140 0 0 {name=X22}
C {devices/lab_wire.sym} 4490 -580 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4520 -280 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4710 -430 0 1 {name=l70 sig_type=std_logic lab=g}
C {inverter_delay.sym} 3990 260 0 0 {name=X23}
C {devices/lab_wire.sym} 3780 -180 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3810 120 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3650 -30 0 0 {name=l73 sig_type=std_logic lab=g}
C {inverter_delay.sym} 4390 260 0 0 {name=X24}
C {devices/lab_wire.sym} 4180 -180 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4210 120 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4400 -30 0 1 {name=l76 sig_type=std_logic lab=8}
C {inverter_delay.sym} 4730 260 0 0 {name=X25}
C {devices/lab_wire.sym} 4520 -180 0 0 {name=l77 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4550 120 0 1 {name=l78 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4740 -30 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 3570 -1250 0 1 {name=l164 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 5750 -1340 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 5750 -1300 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 5650 -890 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 5640 -850 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 6650 -1060 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {devices/lab_wire.sym} 5630 -450 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 5630 -410 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 5530 0 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 5520 40 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 7350 -620 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2620 -1450 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3160 -1510 0 0 {name=p4 lab=VOUT}
C {devices/lab_wire.sym} 5880 -1430 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5890 -1200 0 1 {name=l14 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1870 30 0 0 {name=C1
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1870 110 0 1 {name=l88 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1860 -370 0 0 {name=C2
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1860 -290 0 1 {name=l89 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1850 -760 0 0 {name=C3
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1850 -680 0 1 {name=l90 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 1830 -1190 0 0 {name=C4
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 1830 -1110 0 1 {name=l91 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4020 20 0 0 {name=C9
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4020 100 0 1 {name=l96 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4010 -380 0 0 {name=C10
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4010 -300 0 1 {name=l97 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 4000 -770 0 0 {name=C11
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 4000 -690 0 1 {name=l98 sig_type=std_logic lab=VSS}
C {devices/capa.sym} 3980 -1200 0 0 {name=C12
m=1
value=400f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 3980 -1120 0 1 {name=l99 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5780 -1250 0 0 {name=X_OR1}
C {devices/lab_wire.sym} 5790 -980 0 0 {name=l24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5800 -750 0 1 {name=l34 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5690 -800 0 0 {name=X_OR2}
C {devices/lab_wire.sym} 5760 -540 0 0 {name=l41 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5770 -310 0 1 {name=l44 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5660 -360 0 0 {name=X_OR3}
C {devices/lab_wire.sym} 5670 -90 0 0 {name=l46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5680 140 0 1 {name=l80 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5570 90 0 0 {name=X_OR4}
C {devices/lab_wire.sym} 6390 -1170 0 0 {name=l81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6400 -940 0 1 {name=l82 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6290 -990 0 0 {name=X_OR5}
C {devices/lab_wire.sym} 6360 -280 0 0 {name=l85 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6370 -50 0 1 {name=l92 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6260 -100 0 0 {name=X_OR6}
C {devices/lab_wire.sym} 7090 -730 0 0 {name=l83 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7100 -500 0 1 {name=l84 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6990 -550 0 0 {name=X_OR7}
C {devices/lab_wire.sym} 2890 -1620 0 0 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2900 -1390 0 1 {name=l87 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 2790 -1440 0 0 {name=X_OR8}
