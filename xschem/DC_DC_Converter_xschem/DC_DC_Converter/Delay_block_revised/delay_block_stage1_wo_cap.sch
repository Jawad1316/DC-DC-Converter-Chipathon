v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1430 -1240 1490 -1240 {
lab=VIN}
N 1590 -1240 1680 -1240 {
lab=#net1}
N 1680 -1240 1740 -1240 {
lab=#net1}
N 1840 -1240 1930 -1240 {
lab=#net2}
N 2220 -1240 2310 -1240 {
lab=a}
N 1620 -810 1680 -810 {
lab=a}
N 1780 -810 1870 -810 {
lab=#net3}
N 1870 -810 1930 -810 {
lab=#net3}
N 2030 -810 2120 -810 {
lab=#net4}
N 2450 -810 2540 -810 {
lab=b}
N 1620 -420 1680 -420 {
lab=b}
N 1780 -420 1870 -420 {
lab=#net5}
N 1870 -420 1930 -420 {
lab=#net5}
N 2030 -420 2120 -420 {
lab=#net6}
N 2400 -420 2490 -420 {
lab=c}
N 1755 -132.5 1755 -62.5 {
lab=VDD}
N 1725 -132.5 1755 -132.5 {
lab=VDD}
N 1755 20 1755 90 {
lab=VSS}
N 1755 90 1775 90 {
lab=VSS}
N 1650 -20 1710 -20 {
lab=c}
N 1810 -20 1900 -20 {
lab=#net7}
N 1900 -20 1960 -20 {
lab=#net7}
N 2060 -20 2150 -20 {
lab=#net8}
N 2460 -20 2550 -20 {
lab=d}
N 1470 -1530 2710 -1530 {
lab=VIN}
N 1470 -1530 1470 -1240 {
lab=VIN}
N 3870 -1250 3960 -1250 {
lab=#net9}
N 3960 -1250 4020 -1250 {
lab=#net9}
N 4120 -1250 4210 -1250 {
lab=#net10}
N 4490 -1250 4580 -1250 {
lab=e}
N 3750 -820 3810 -820 {
lab=e}
N 3910 -820 4000 -820 {
lab=#net11}
N 4000 -820 4060 -820 {
lab=#net11}
N 4160 -820 4250 -820 {
lab=#net12}
N 4600 -820 4690 -820 {
lab=f}
N 3750 -430 3810 -430 {
lab=f}
N 3910 -430 4000 -430 {
lab=#net13}
N 4000 -430 4060 -430 {
lab=#net13}
N 4160 -430 4250 -430 {
lab=#net14}
N 4520 -430 4610 -430 {
lab=g}
N 3780 -30 3840 -30 {
lab=g}
N 3940 -30 4030 -30 {
lab=#net15}
N 4030 -30 4090 -30 {
lab=#net15}
N 4190 -30 4280 -30 {
lab=#net16}
N 4620 -30 4710 -30 {
lab=h}
N 3690 -1250 3770 -1250 {
lab=d}
N 5990 -1320 6080 -1320 {
lab=#net17}
N 5990 -870 6080 -870 {
lab=#net18}
N 6180 -1080 6310 -1080 {
lab=#net17}
N 6180 -1320 6180 -1080 {
lab=#net17}
N 6080 -1320 6180 -1320 {
lab=#net17}
N 6170 -1040 6310 -1040 {
lab=#net18}
N 6170 -1040 6170 -870 {
lab=#net18}
N 6080 -870 6170 -870 {
lab=#net18}
N 6590 -1060 6720 -1060 {
lab=ph1}
N 5700 -1340 5800 -1340 {
lab=1}
N 5700 -1300 5800 -1300 {
lab=b}
N 5620 -890 5710 -890 {
lab=3}
N 5620 -850 5710 -850 {
lab=d}
N 5960 -430 6050 -430 {
lab=#net19}
N 5960 20 6050 20 {
lab=#net20}
N 6150 -190 6280 -190 {
lab=#net19}
N 6150 -430 6150 -190 {
lab=#net19}
N 6050 -430 6150 -430 {
lab=#net19}
N 6140 -150 6280 -150 {
lab=#net20}
N 6140 -150 6140 20 {
lab=#net20}
N 6050 20 6140 20 {
lab=#net20}
N 6650 -170 6780 -170 {
lab=#net21}
N 5580 -450 5680 -450 {
lab=5}
N 5580 -410 5680 -410 {
lab=f}
N 5500 0 5590 0 {
lab=7}
N 5500 40 5590 40 {
lab=h}
N 7290 -620 7420 -620 {
lab=vin2}
N 2620 -1490 2710 -1490 {
lab=vin2}
N 2620 -1490 2620 -1410 {
lab=vin2}
N 1280 -1240 1430 -1240 {
lab=VIN}
N 6710 -1060 6950 -1060 {
lab=ph1}
N 6950 -1060 6950 -640 {
lab=ph1}
N 6950 -640 7010 -640 {
lab=ph1}
N 6780 -170 6900 -170 {
lab=#net21}
N 6900 -590 6900 -170 {
lab=#net21}
N 5950 -1320 5990 -1320 {
lab=#net17}
N 5850 -1430 5850 -1380 {
lab=VDD}
N 5850 -1430 5890 -1430 {
lab=VDD}
N 5850 -1260 5850 -1200 {
lab=VSS}
N 5850 -1200 5900 -1200 {
lab=VSS}
N 5900 -870 5990 -870 {
lab=#net18}
N 5860 -870 5900 -870 {
lab=#net18}
N 5760 -980 5760 -930 {
lab=VDD}
N 5760 -980 5800 -980 {
lab=VDD}
N 5760 -810 5760 -750 {
lab=VSS}
N 5760 -750 5810 -750 {
lab=VSS}
N 5870 -430 5960 -430 {
lab=#net19}
N 5830 -430 5870 -430 {
lab=#net19}
N 5730 -540 5730 -490 {
lab=VDD}
N 5730 -540 5770 -540 {
lab=VDD}
N 5730 -370 5730 -310 {
lab=VSS}
N 5730 -310 5780 -310 {
lab=VSS}
N 5870 20 5960 20 {
lab=#net20}
N 5780 20 5870 20 {
lab=#net20}
N 5740 20 5780 20 {
lab=#net20}
N 5640 -90 5640 -40 {
lab=VDD}
N 5640 -90 5680 -90 {
lab=VDD}
N 5640 80 5640 140 {
lab=VSS}
N 5640 140 5690 140 {
lab=VSS}
N 6500 -1060 6590 -1060 {
lab=ph1}
N 6460 -1060 6500 -1060 {
lab=ph1}
N 6360 -1170 6360 -1120 {
lab=VDD}
N 6360 -1170 6400 -1170 {
lab=VDD}
N 6360 -1000 6360 -940 {
lab=VSS}
N 6360 -940 6410 -940 {
lab=VSS}
N 6560 -170 6650 -170 {
lab=#net21}
N 6470 -170 6560 -170 {
lab=#net21}
N 6430 -170 6470 -170 {
lab=#net21}
N 6330 -280 6330 -230 {
lab=VDD}
N 6330 -280 6370 -280 {
lab=VDD}
N 6330 -110 6330 -50 {
lab=VSS}
N 6330 -50 6380 -50 {
lab=VSS}
N 7200 -620 7290 -620 {
lab=vin2}
N 7160 -620 7200 -620 {
lab=vin2}
N 7060 -730 7060 -680 {
lab=VDD}
N 7060 -730 7100 -730 {
lab=VDD}
N 7060 -560 7060 -500 {
lab=VSS}
N 7060 -500 7110 -500 {
lab=VSS}
N 6900 -600 7010 -600 {
lab=#net21}
N 6900 -600 6900 -590 {
lab=#net21}
N 2710 -1530 2810 -1530 {
lab=VIN}
N 2710 -1490 2810 -1490 {
lab=vin2}
N 2960 -1510 3000 -1510 {
lab=VOUT}
N 2860 -1620 2860 -1570 {
lab=VDD}
N 2860 -1620 2900 -1620 {
lab=VDD}
N 2860 -1450 2860 -1390 {
lab=VSS}
N 2860 -1390 2910 -1390 {
lab=VSS}
N 2005 -132.5 2005 -62.5 {
lab=VDD}
N 1975 -132.5 2005 -132.5 {
lab=VDD}
N 2005 20 2005 90 {
lab=VSS}
N 2005 90 2025 90 {
lab=VSS}
N 2405 -132.5 2405 -62.5 {
lab=VDD}
N 2375 -132.5 2405 -132.5 {
lab=VDD}
N 2405 20 2405 90 {
lab=VSS}
N 2405 90 2425 90 {
lab=VSS}
N 1725 -532.5 1725 -462.5 {
lab=VDD}
N 1695 -532.5 1725 -532.5 {
lab=VDD}
N 1725 -380 1725 -310 {
lab=VSS}
N 1725 -310 1745 -310 {
lab=VSS}
N 1975 -532.5 1975 -462.5 {
lab=VDD}
N 1945 -532.5 1975 -532.5 {
lab=VDD}
N 1975 -380 1975 -310 {
lab=VSS}
N 1975 -310 1995 -310 {
lab=VSS}
N 2345 -532.5 2345 -462.5 {
lab=VDD}
N 2315 -532.5 2345 -532.5 {
lab=VDD}
N 2345 -380 2345 -310 {
lab=VSS}
N 2345 -310 2365 -310 {
lab=VSS}
N 1725 -922.5 1725 -852.5 {
lab=VDD}
N 1695 -922.5 1725 -922.5 {
lab=VDD}
N 1725 -770 1725 -700 {
lab=VSS}
N 1725 -700 1745 -700 {
lab=VSS}
N 1975 -922.5 1975 -852.5 {
lab=VDD}
N 1945 -922.5 1975 -922.5 {
lab=VDD}
N 1975 -770 1975 -700 {
lab=VSS}
N 1975 -700 1995 -700 {
lab=VSS}
N 2395 -922.5 2395 -852.5 {
lab=VDD}
N 2365 -922.5 2395 -922.5 {
lab=VDD}
N 2395 -770 2395 -700 {
lab=VSS}
N 2395 -700 2415 -700 {
lab=VSS}
N 1535 -1352.5 1535 -1282.5 {
lab=VDD}
N 1505 -1352.5 1535 -1352.5 {
lab=VDD}
N 1535 -1200 1535 -1130 {
lab=VSS}
N 1535 -1130 1555 -1130 {
lab=VSS}
N 1785 -1352.5 1785 -1282.5 {
lab=VDD}
N 1755 -1352.5 1785 -1352.5 {
lab=VDD}
N 1785 -1200 1785 -1130 {
lab=VSS}
N 1785 -1130 1805 -1130 {
lab=VSS}
N 2165 -1352.5 2165 -1282.5 {
lab=VDD}
N 2135 -1352.5 2165 -1352.5 {
lab=VDD}
N 2165 -1200 2165 -1130 {
lab=VSS}
N 2165 -1130 2185 -1130 {
lab=VSS}
N 3815 -1362.5 3815 -1292.5 {
lab=VDD}
N 3785 -1362.5 3815 -1362.5 {
lab=VDD}
N 3815 -1210 3815 -1140 {
lab=VSS}
N 3815 -1140 3835 -1140 {
lab=VSS}
N 4065 -1362.5 4065 -1292.5 {
lab=VDD}
N 4035 -1362.5 4065 -1362.5 {
lab=VDD}
N 4065 -1210 4065 -1140 {
lab=VSS}
N 4065 -1140 4085 -1140 {
lab=VSS}
N 4435 -1362.5 4435 -1292.5 {
lab=VDD}
N 4405 -1362.5 4435 -1362.5 {
lab=VDD}
N 4435 -1210 4435 -1140 {
lab=VSS}
N 4435 -1140 4455 -1140 {
lab=VSS}
N 3855 -932.5 3855 -862.5 {
lab=VDD}
N 3825 -932.5 3855 -932.5 {
lab=VDD}
N 3855 -780 3855 -710 {
lab=VSS}
N 3855 -710 3875 -710 {
lab=VSS}
N 4105 -932.5 4105 -862.5 {
lab=VDD}
N 4075 -932.5 4105 -932.5 {
lab=VDD}
N 4105 -780 4105 -710 {
lab=VSS}
N 4105 -710 4125 -710 {
lab=VSS}
N 4545 -932.5 4545 -862.5 {
lab=VDD}
N 4515 -932.5 4545 -932.5 {
lab=VDD}
N 4545 -780 4545 -710 {
lab=VSS}
N 4545 -710 4565 -710 {
lab=VSS}
N 3855 -542.5 3855 -472.5 {
lab=VDD}
N 3825 -542.5 3855 -542.5 {
lab=VDD}
N 3855 -390 3855 -320 {
lab=VSS}
N 3855 -320 3875 -320 {
lab=VSS}
N 4105 -542.5 4105 -472.5 {
lab=VDD}
N 4075 -542.5 4105 -542.5 {
lab=VDD}
N 4105 -390 4105 -320 {
lab=VSS}
N 4105 -320 4125 -320 {
lab=VSS}
N 4465 -542.5 4465 -472.5 {
lab=VDD}
N 4435 -542.5 4465 -542.5 {
lab=VDD}
N 4465 -390 4465 -320 {
lab=VSS}
N 4465 -320 4485 -320 {
lab=VSS}
N 3885 -142.5 3885 -72.5 {
lab=VDD}
N 3855 -142.5 3885 -142.5 {
lab=VDD}
N 3885 10 3885 80 {
lab=VSS}
N 3885 80 3905 80 {
lab=VSS}
N 4135 -142.5 4135 -72.5 {
lab=VDD}
N 4105 -142.5 4135 -142.5 {
lab=VDD}
N 4135 10 4135 80 {
lab=VSS}
N 4135 80 4155 80 {
lab=VSS}
N 4565 -142.5 4565 -72.5 {
lab=VDD}
N 4535 -142.5 4565 -142.5 {
lab=VDD}
N 4565 10 4565 80 {
lab=VSS}
N 4565 80 4585 80 {
lab=VSS}
N 3000 -1510 3010 -1510 {
lab=VOUT}
N 3010 -1510 3020 -1510 {
lab=VOUT}
N 2030 -1240 2120 -1240 {
lab=1}
N 1975 -1352.5 1975 -1282.5 {
lab=VDD}
N 1945 -1352.5 1975 -1352.5 {
lab=VDD}
N 1975 -1200 1975 -1130 {
lab=VSS}
N 1975 -1130 1995 -1130 {
lab=VSS}
N 2165 -922.5 2165 -852.5 {
lab=VDD}
N 2135 -922.5 2165 -922.5 {
lab=VDD}
N 2165 -770 2165 -700 {
lab=VSS}
N 2165 -700 2185 -700 {
lab=VSS}
N 2220 -810 2350 -810 {
lab=2}
N 2165 -532.5 2165 -462.5 {
lab=VDD}
N 2135 -532.5 2165 -532.5 {
lab=VDD}
N 2165 -380 2165 -310 {
lab=VSS}
N 2165 -310 2185 -310 {
lab=VSS}
N 2220 -420 2300 -420 {
lab=3}
N 2195 -132.5 2195 -62.5 {
lab=VDD}
N 2165 -132.5 2195 -132.5 {
lab=VDD}
N 2195 20 2195 90 {
lab=VSS}
N 2195 90 2215 90 {
lab=VSS}
N 2250 -20 2360 -20 {
lab=4}
N 4255 -1362.5 4255 -1292.5 {
lab=VDD}
N 4225 -1362.5 4255 -1362.5 {
lab=VDD}
N 4255 -1210 4255 -1140 {
lab=VSS}
N 4255 -1140 4275 -1140 {
lab=VSS}
N 4310 -1250 4390 -1250 {
lab=5}
N 4295 -932.5 4295 -862.5 {
lab=VDD}
N 4265 -932.5 4295 -932.5 {
lab=VDD}
N 4295 -780 4295 -710 {
lab=VSS}
N 4295 -710 4315 -710 {
lab=VSS}
N 4350 -820 4500 -820 {
lab=6}
N 4295 -542.5 4295 -472.5 {
lab=VDD}
N 4265 -542.5 4295 -542.5 {
lab=VDD}
N 4295 -390 4295 -320 {
lab=VSS}
N 4295 -320 4315 -320 {
lab=VSS}
N 4350 -430 4420 -430 {
lab=7}
N 4325 -142.5 4325 -72.5 {
lab=VDD}
N 4295 -142.5 4325 -142.5 {
lab=VDD}
N 4325 10 4325 80 {
lab=VSS}
N 4325 80 4345 80 {
lab=VSS}
N 4380 -30 4520 -30 {
lab=8}
C {devices/lab_wire.sym} 2280 -1240 0 1 {name=l10 sig_type=std_logic lab=a}
C {devices/lab_wire.sym} 1640 -810 0 0 {name=l13 sig_type=std_logic lab=a}
C {devices/lab_wire.sym} 2330 -810 0 1 {name=l17 sig_type=std_logic lab=2}
C {devices/lab_wire.sym} 2510 -810 0 1 {name=l20 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 1640 -420 0 0 {name=l23 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 2270 -420 0 1 {name=l27 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 2460 -420 0 1 {name=l30 sig_type=std_logic lab=c}
C {devices/lab_wire.sym} 1735 -132.5 0 0 {name=l31 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1765 90 0 1 {name=l32 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1670 -20 0 0 {name=l33 sig_type=std_logic lab=c}
C {devices/lab_wire.sym} 2330 -20 0 1 {name=l37 sig_type=std_logic lab=4}
C {devices/lab_wire.sym} 2520 -20 0 1 {name=l40 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 4360 -1250 0 1 {name=l49 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 4550 -1250 0 1 {name=l52 sig_type=std_logic lab=e}
C {devices/lab_wire.sym} 3770 -820 0 0 {name=l55 sig_type=std_logic lab=e}
C {devices/lab_wire.sym} 4470 -820 0 1 {name=l58 sig_type=std_logic lab=6}
C {devices/lab_wire.sym} 4660 -820 0 1 {name=l61 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 3770 -430 0 0 {name=l64 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 4390 -430 0 1 {name=l67 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 4580 -430 0 1 {name=l70 sig_type=std_logic lab=g}
C {devices/lab_wire.sym} 3800 -30 0 0 {name=l73 sig_type=std_logic lab=g}
C {devices/lab_wire.sym} 4490 -30 0 1 {name=l76 sig_type=std_logic lab=8}
C {devices/lab_wire.sym} 4680 -30 0 1 {name=l79 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 3720 -1250 0 1 {name=l164 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 5750 -1340 0 0 {name=l178 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 5750 -1300 0 0 {name=l179 sig_type=std_logic lab=b}
C {devices/lab_wire.sym} 5650 -890 0 0 {name=l180 sig_type=std_logic lab=3}
C {devices/lab_wire.sym} 5640 -850 0 0 {name=l181 sig_type=std_logic lab=d}
C {devices/lab_wire.sym} 6650 -1060 0 0 {name=l182 sig_type=std_logic lab=ph1}
C {devices/lab_wire.sym} 5630 -450 0 0 {name=l195 sig_type=std_logic lab=5}
C {devices/lab_wire.sym} 5630 -410 0 0 {name=l196 sig_type=std_logic lab=f}
C {devices/lab_wire.sym} 5530 0 0 0 {name=l197 sig_type=std_logic lab=7}
C {devices/lab_wire.sym} 5520 40 0 0 {name=l198 sig_type=std_logic lab=h}
C {devices/lab_wire.sym} 7350 -620 0 0 {name=l216 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 2620 -1450 0 0 {name=l236 sig_type=std_logic lab=vin2}
C {devices/lab_wire.sym} 1410 -1240 0 1 {name=l244 sig_type=std_logic lab=VIN}
C {devices/iopin.sym} 1360 -1100 0 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 1360 -1070 0 0 {name=p2 lab=VSS}
C {devices/iopin.sym} 1280 -1240 0 1 {name=p3 lab=VIN}
C {devices/iopin.sym} 3020 -1510 0 0 {name=p4 lab=VOUT}
C {devices/lab_wire.sym} 5880 -1430 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5890 -1200 0 1 {name=l14 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5780 -1250 0 0 {name=X_OR1}
C {devices/lab_wire.sym} 5790 -980 0 0 {name=l24 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5800 -750 0 1 {name=l34 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5690 -800 0 0 {name=X_OR2}
C {devices/lab_wire.sym} 5760 -540 0 0 {name=l41 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5770 -310 0 1 {name=l44 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5660 -360 0 0 {name=X_OR3}
C {devices/lab_wire.sym} 5670 -90 0 0 {name=l46 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5680 140 0 1 {name=l80 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 5570 90 0 0 {name=X_OR4}
C {devices/lab_wire.sym} 6390 -1170 0 0 {name=l81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6400 -940 0 1 {name=l82 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6290 -990 0 0 {name=X_OR5}
C {devices/lab_wire.sym} 6360 -280 0 0 {name=l85 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 6370 -50 0 1 {name=l92 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6260 -100 0 0 {name=X_OR6}
C {devices/lab_wire.sym} 7090 -730 0 0 {name=l83 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 7100 -500 0 1 {name=l84 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 6990 -550 0 0 {name=X_OR7}
C {devices/lab_wire.sym} 2890 -1620 0 0 {name=l86 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2900 -1390 0 1 {name=l87 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/OR_GATE/OR.sym} 2790 -1440 0 0 {name=X_OR8}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1490 100 0 0 {name=X13}
C {devices/lab_wire.sym} 1985 -132.5 0 0 {name=l35 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2015 90 0 1 {name=l36 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1740 100 0 0 {name=X10}
C {devices/lab_wire.sym} 2385 -132.5 0 0 {name=l38 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2415 90 0 1 {name=l39 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 2140 100 0 0 {name=X11}
C {devices/lab_wire.sym} 1705 -532.5 0 0 {name=l21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1735 -310 0 1 {name=l22 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1460 -300 0 0 {name=X7}
C {devices/lab_wire.sym} 1955 -532.5 0 0 {name=l25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1985 -310 0 1 {name=l26 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1710 -300 0 0 {name=X8}
C {devices/lab_wire.sym} 2325 -532.5 0 0 {name=l28 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2355 -310 0 1 {name=l29 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 2080 -300 0 0 {name=X9}
C {devices/lab_wire.sym} 1705 -922.5 0 0 {name=l42 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1735 -700 0 1 {name=l43 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1460 -690 0 0 {name=X4}
C {devices/lab_wire.sym} 1955 -922.5 0 0 {name=l11 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1985 -700 0 1 {name=l12 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1710 -690 0 0 {name=X5}
C {devices/lab_wire.sym} 2375 -922.5 0 0 {name=l15 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2405 -700 0 1 {name=l16 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 2130 -690 0 0 {name=X6}
C {devices/lab_wire.sym} 1515 -1352.5 0 0 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1545 -1130 0 1 {name=l2 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1270 -1120 0 0 {name=X1}
C {devices/lab_wire.sym} 1765 -1352.5 0 0 {name=l5 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1795 -1130 0 1 {name=l6 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1520 -1120 0 0 {name=X2}
C {devices/lab_wire.sym} 2145 -1352.5 0 0 {name=l7 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2175 -1130 0 1 {name=l9 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1900 -1120 0 0 {name=X3}
C {devices/lab_wire.sym} 3795 -1362.5 0 0 {name=l18 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3825 -1140 0 1 {name=l19 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3550 -1130 0 0 {name=X12}
C {devices/lab_wire.sym} 4045 -1362.5 0 0 {name=l3 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4075 -1140 0 1 {name=l45 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3800 -1130 0 0 {name=X14}
C {devices/lab_wire.sym} 4415 -1362.5 0 0 {name=l47 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4445 -1140 0 1 {name=l48 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4170 -1130 0 0 {name=X15}
C {devices/lab_wire.sym} 3835 -932.5 0 0 {name=l50 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3865 -710 0 1 {name=l51 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3590 -700 0 0 {name=X16}
C {devices/lab_wire.sym} 4085 -932.5 0 0 {name=l53 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4115 -710 0 1 {name=l54 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3840 -700 0 0 {name=X17}
C {devices/lab_wire.sym} 4525 -932.5 0 0 {name=l56 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4555 -710 0 1 {name=l57 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4280 -700 0 0 {name=X18}
C {devices/lab_wire.sym} 3835 -542.5 0 0 {name=l59 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3865 -320 0 1 {name=l60 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3590 -310 0 0 {name=X19}
C {devices/lab_wire.sym} 4085 -542.5 0 0 {name=l62 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4115 -320 0 1 {name=l63 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3840 -310 0 0 {name=X20}
C {devices/lab_wire.sym} 4445 -542.5 0 0 {name=l65 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4475 -320 0 1 {name=l66 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4200 -310 0 0 {name=X21}
C {devices/lab_wire.sym} 3865 -142.5 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3895 80 0 1 {name=l69 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3620 90 0 0 {name=X22}
C {devices/lab_wire.sym} 4115 -142.5 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4145 80 0 1 {name=l72 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3870 90 0 0 {name=X23}
C {devices/lab_wire.sym} 4545 -142.5 0 0 {name=l74 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4575 80 0 1 {name=l75 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4300 90 0 0 {name=X24}
C {devices/lab_wire.sym} 2070 -1240 0 1 {name=l77 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 1955 -1352.5 0 0 {name=l93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1985 -1130 0 1 {name=l94 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1710 -1120 0 0 {name=X25}
C {devices/lab_wire.sym} 2145 -922.5 0 0 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2175 -700 0 1 {name=l95 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1900 -690 0 0 {name=X26}
C {devices/lab_wire.sym} 2145 -532.5 0 0 {name=l8 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2175 -310 0 1 {name=l100 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1900 -300 0 0 {name=X27}
C {devices/lab_wire.sym} 2175 -132.5 0 0 {name=l101 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2205 90 0 1 {name=l102 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 1930 100 0 0 {name=X28}
C {devices/lab_wire.sym} 4235 -1362.5 0 0 {name=l103 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4265 -1140 0 1 {name=l104 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3990 -1130 0 0 {name=X29}
C {devices/lab_wire.sym} 4275 -932.5 0 0 {name=l105 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4305 -710 0 1 {name=l106 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4030 -700 0 0 {name=X30}
C {devices/lab_wire.sym} 4275 -542.5 0 0 {name=l107 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4305 -320 0 1 {name=l108 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4030 -310 0 0 {name=X31}
C {devices/lab_wire.sym} 4305 -142.5 0 0 {name=l109 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4335 80 0 1 {name=l110 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 4060 90 0 0 {name=X32}
