v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 2720 670 2720 730 {
lab=SAWTOOTH}
N 3410 1030 3460 1030 {
lab=1}
N 3410 1050 3460 1050 {
lab=2}
N 3340 1110 3340 1160 {
lab=IBIAS4}
N 3320 1110 3320 1170 {
lab=IBIAS3}
N 3260 1110 3260 1170 {
lab=VSS}
N 3300 900 3300 960 {
lab=VDD}
N 3130 1010 3190 1010 {
lab=out}
N 3130 1050 3190 1050 {
lab=VH}
N 3130 1070 3190 1070 {
lab=VL}
N 3300 670 3300 730 {
lab=IBIAS3}
N 3390 670 3390 720 {
lab=IBIAS4}
N 3530 1130 3670 1130 {
lab=Enable}
N 3530 940 3670 940 {
lab=Enable}
N 3470 940 3530 940 {
lab=Enable}
N 3610 980 3670 980 {
lab=1}
N 3610 1170 3670 1170 {
lab=2}
N 3797.5 960 3857.5 960 {
lab=Q1}
N 3797.5 1150 3857.5 1150 {
lab=Q2}
N 3720 1210 3720 1230 {
lab=VSS}
N 3720 1070 3720 1090 {
lab=VDD}
N 3720 1020 3720 1040 {
lab=VSS}
N 3720 880 3720 900 {
lab=VDD}
N 3530 940 3530 1130 {
lab=Enable}
N 3100 660 3100 720 {
lab=VH}
N 3180 660 3180 720 {
lab=VL}
N 3000 660 3000 720 {
lab=Enable}
N 3570 1700 3570 1760 {
lab=VSS}
N 3570 1410 3570 1470 {
lab=VDD}
N 3710 1590 3790 1590 {
lab=Q1}
N 3340 1590 3440 1590 {
lab=#net1}
N 3570 2070 3570 2130 {
lab=VSS}
N 3570 1780 3570 1840 {
lab=VDD}
N 3710 1960 3790 1960 {
lab=Q2}
N 2780 1930 2780 1980 {
lab=VSS}
N 2780 1930 2780 1980 {
lab=VSS}
N 2560 1780 2640 1780 {
lab=out}
N 2930 1750 3000 1750 {
lab=Q2D}
N 2930 1820 3000 1820 {
lab=Q1D}
N 2780 1570 2780 1630 {
lab=VDD}
N 3230 1960 3310 1960 {
lab=#net2}
N 3410 1960 3440 1960 {
lab=#net3}
N 3170 1590 3240 1590 {
lab=Q1D}
N 3295 1630 3295 1667.5 {
lab=VSS}
N 3295 1517.5 3295 1547.5 {
lab=VDD}
N 3060 1960 3130 1960 {
lab=Q2D}
N 3185 2000 3185 2037.5 {
lab=VSS}
N 3185 1887.5 3185 1917.5 {
lab=VDD}
N 1720 920 1770 920 {
lab=V_P}
N 1810 1070 1810 1100 {
lab=VSS}
N 1870 980 1910 980 {
lab=IL}
N 2030 980 2030 1000 {
lab=out}
N 1970 980 2030 980 {
lab=out}
N 2030 1060 2030 1100 {
lab=#net4}
N 2030 980 2140 980 {
lab=out}
N 2110 1270 2110 1320 {
lab=VDD}
N 2130 1430 2130 1480 {
lab=VSS}
N 2100 1430 2100 1480 {
lab=IBIAS1}
N 2180 1390 2230 1390 {
lab=#net5}
N 2180 1360 2230 1360 {
lab=VREF}
N 2220 720 2220 730 {
lab=VDD}
N 2220 670 2220 720 {
lab=VDD}
N 2310 700 2310 720 {
lab=VSS}
N 2310 720 2310 730 {
lab=VSS}
N 2310 670 2310 700 {
lab=VSS}
N 2410 680 2410 740 {
lab=IBIAS1}
N 1730 1270 1730 1320 {
lab=VDD}
N 1730 1440 1730 1490 {
lab=VSS}
N 2120 700 2120 720 {
lab=VREF}
N 2120 720 2120 730 {
lab=VREF}
N 2120 670 2120 700 {
lab=VREF}
N 2230 1390 2260 1390 {
lab=#net5}
N 1710 1270 1710 1320 {
lab=IBIAS2}
N 1530 920 1720 920 {
lab=V_P}
N 2330 980 2330 1000 {
lab=out}
N 2330 1060 2330 1110 {
lab=#net5}
N 2330 1200 2330 1250 {
lab=VSS}
N 2110 1230 2190 1230 {
lab=#net6}
N 1960 1230 2050 1230 {
lab=#net7}
N 1960 1230 1960 1370 {
lab=#net7}
N 2270 1230 2270 1360 {
lab=#net5}
N 2250 1230 2270 1230 {
lab=#net5}
N 1960 1120 2100 1120 {
lab=#net7}
N 2160 1120 2270 1120 {
lab=#net5}
N 2270 1160 2270 1230 {
lab=#net5}
N 1960 1370 1990 1370 {
lab=#net7}
N 2270 1360 2270 1390 {
lab=#net5}
N 2260 1390 2270 1390 {
lab=#net5}
N 2330 980 2480 980 {
lab=out}
N 2480 980 2480 990 {
lab=out}
N 2480 1050 2480 1060 {
lab=#net8}
N 2320 980 2330 980 {
lab=out}
N 2270 1100 2270 1160 {
lab=#net5}
N 2270 1100 2330 1100 {
lab=#net5}
N 2330 1110 2330 1140 {
lab=#net5}
N 2600 980 2600 1020 {
lab=out}
N 2480 980 2600 980 {
lab=out}
N 2600 1080 2600 1120 {
lab=VSS}
N 1790 1390 1960 1390 {
lab=#net7}
N 1960 1370 1960 1390 {
lab=#net7}
N 1720 1040 1770 1040 {
lab=V_N}
N 1810 1040 1810 1070 {
lab=VSS}
N 2600 980 2730 980 {
lab=out}
N 2730 1130 2730 1170 {
lab=VSS}
N 2730 1040 2730 1070 {
lab=#net9}
N 2770 1010 2840 1010 {
lab=DL}
N 2840 1010 2840 1030 {
lab=DL}
N 1540 1270 1540 1320 {
lab=VDD}
N 1540 1430 1540 1480 {
lab=VSS}
N 1300 920 1430 920 {
lab=PH2}
N 1300 920 1300 1360 {
lab=PH2}
N 1475 960 1475 987.5 {
lab=VSS}
N 1475 842.5 1475 877.5 {
lab=VDD}
N 1660 1040 1720 1040 {
lab=V_N}
N 1400 1040 1560 1040 {
lab=PH1}
N 1400 1040 1400 1130 {
lab=PH1}
N 1605 1080 1605 1117.5 {
lab=VSS}
N 1605 967.5 1605 997.5 {
lab=VDD}
N 1400 1360 1460 1360 {
lab=PH1}
N 1400 1130 1400 1360 {
lab=PH1}
N 1300 1390 1460 1390 {
lab=PH2}
N 1300 1360 1300 1390 {
lab=PH2}
N 1960 1120 1960 1230 {
lab=#net7}
N 2330 1120 2380 1120 {
lab=#net5}
N 2380 1120 2480 1120 {
lab=#net5}
N 2130 1430 2130 1480 {
lab=VSS}
N 2670 1010 2730 1010 {
lab=VDD}
N 1790 1370 1900 1370 {
lab=SAWTOOTH}
N 2080 1250 2080 1270 {
lab=VSS}
N 2440 1020 2460 1020 {
lab=VSS}
N 2290 1030 2310 1030 {
lab=VSS}
N 2290 1170 2310 1170 {
lab=VSS}
N 2000 1100 2030 1100 {
lab=#net4}
N 1460 1360 1470 1360 {
lab=PH1}
N 1460 1390 1470 1390 {
lab=PH2}
N 1810 1100 1890 1100 {
lab=VSS}
N 1950 1100 2000 1100 {
lab=#net4}
N 1620 1380 1660 1380 {
lab=#net10}
N 2540 680 2540 740 {
lab=IBIAS2}
N 2410 790 2410 810 {
lab=VSS}
N 2540 790 2540 810 {
lab=VSS}
N 2410 810 2410 820 {
lab=VSS}
N 2540 810 2540 820 {
lab=VSS}
N 1610 1380 1620 1380 {
lab=#net10}
N 2230 1360 2240 1360 {
lab=VREF}
N 2660 1010 2670 1010 {
lab=VDD}
N 3300 780 3300 800 {
lab=VSS}
N 3300 800 3300 810 {
lab=VSS}
N 3390 780 3390 800 {
lab=VSS}
N 3390 800 3390 810 {
lab=VSS}
N 3720 870 3720 880 {
lab=VDD}
N 2730 980 3130 980 {
lab=out}
N 3130 980 3130 1010 {
lab=out}
N 3365 1887.5 3365 1917.5 {
lab=VDD}
N 3365 2000 3365 2037.5 {
lab=VSS}
N 2500 1780 2560 1780 {
lab=out}
N 2200 980 2330 980 {
lab=out}
N 2140 980 2200 980 {
lab=out}
N 1840 680 1840 710 {
lab=VDD}
N 1840 610 1840 680 {
lab=VDD}
N 1810 1040 1840 1040 {
lab=VSS}
N 1840 920 1840 1040 {
lab=VSS}
N 1660 780 1730 780 {
lab=V_P}
N 1660 820 1730 820 {
lab=V_N}
N 1960 810 2010 810 {
lab=IL}
C {devices/code_shown.sym} 1090 1150 0 0 {name=NGSPICE
only_toplevel=true
value="

.control

tran 200p 8u
plot V(out) 
plot v(VH) v(VL)
.endc
" }
C {devices/vsource.sym} 2720 760 0 0 {name=V6 value="pwl(0 0 9.99ns 1.8 10ns 0) r=0"}
C {devices/gnd.sym} 2720 790 0 0 {name=l28 lab=GND}
C {devices/gnd.sym} 2720 790 0 0 {name=l29 lab=GND}
C {devices/lab_wire.sym} 2720 700 0 0 {name=l30 sig_type=std_logic lab=SAWTOOTH}
C {devices/lab_wire.sym} 3340 1140 0 1 {name=l48 sig_type=std_logic lab=IBIAS4}
C {devices/lab_wire.sym} 3320 1140 0 0 {name=l49 sig_type=std_logic lab=IBIAS3}
C {devices/lab_pin.sym} 3260 1140 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3300 930 0 0 {name=l51 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 3160 1050 1 0 {name=l53 sig_type=std_logic lab=VH}
C {devices/lab_pin.sym} 3160 1070 3 0 {name=l54 sig_type=std_logic lab=VL}
C {DC_DC_Converter/Comparator_Pair/cmp_pair.sym} 3170 1110 0 0 {name=XM1}
C {devices/lab_wire.sym} 3450 1030 0 0 {name=l47 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 3450 1050 0 0 {name=l87 sig_type=std_logic lab=2}
C {devices/isource.sym} 3300 750 0 0 {name=I2 value=50u}
C {devices/isource.sym} 3390 750 0 0 {name=I3 value=50u}
C {devices/lab_wire.sym} 3300 690 0 0 {name=l59 sig_type=std_logic lab=IBIAS3}
C {devices/lab_wire.sym} 3390 700 0 1 {name=l61 sig_type=std_logic lab=IBIAS4}
C {devices/lab_pin.sym} 3720 1230 0 0 {name=l84 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3837.5 1150 0 0 {name=l86 sig_type=std_logic lab=Q2}
C {devices/lab_wire.sym} 3640 980 0 0 {name=l64 sig_type=std_logic lab=1}
C {devices/lab_wire.sym} 3640 1170 0 0 {name=l88 sig_type=std_logic lab=2}
C {devices/lab_wire.sym} 3500 940 0 0 {name=l91 sig_type=std_logic lab=Enable}
C {devices/lab_pin.sym} 3720 1080 0 0 {name=l94 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3837.5 960 0 0 {name=l79 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 3720 1030 0 0 {name=l52 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3720 880 0 0 {name=l55 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 3100 750 0 0 {name=V7 value=1.05}
C {devices/gnd.sym} 3100 780 0 0 {name=l56 lab=GND}
C {devices/lab_pin.sym} 3100 690 0 0 {name=l57 sig_type=std_logic lab=VH}
C {devices/vsource.sym} 3180 750 0 0 {name=V8 value=0.95}
C {devices/gnd.sym} 3180 780 0 0 {name=l65 lab=GND}
C {devices/lab_pin.sym} 3180 690 0 0 {name=l66 sig_type=std_logic lab=VL}
C {devices/gnd.sym} 3000 780 0 0 {name=l89 lab=GND}
C {devices/lab_pin.sym} 3000 690 0 0 {name=l90 sig_type=std_logic lab=Enable}
C {devices/vsource.sym} 3000 750 0 0 {name=V10 value=1.8}
C {DC_DC_Converter/Delay_block_revised/AND_GATE/AND.sym} 3650 1030 0 0 {name=X_AND1}
C {DC_DC_Converter/Delay_block_revised/AND_GATE/AND.sym} 3650 1220 0 0 {name=X_AND2}
C {devices/lab_pin.sym} 3570 1730 0 0 {name=l67 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3570 1440 0 0 {name=l68 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3767.5 1590 0 0 {name=l69 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} 3570 2100 0 0 {name=l70 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 3570 1810 0 0 {name=l71 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3097.5 1960 0 0 {name=l72 sig_type=std_logic lab=Q2D}
C {devices/lab_wire.sym} 3767.5 1960 0 0 {name=l73 sig_type=std_logic lab=Q2}
C {DC_DC_Converter/Delay_block_revised/delay_block_stage1.sym} 5170 2650 0 1 {name=XD1}
C {DC_DC_Converter/Delay_block_revised/delay_block_stage1.sym} 5170 3020 0 1 {name=XD2}
C {devices/lab_wire.sym} 2780 1960 0 1 {name=l103 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/current_pump/current_pump_for_symbol.sym} 4330 2930 0 1 {name=X3}
C {devices/lab_wire.sym} 2977.5 1820 0 0 {name=l77 sig_type=std_logic lab=Q1D}
C {DC_DC_Converter/Delay_block_revised/Inverter_0/Inverter0.sym} 3630 2080 0 1 {name=X4}
C {devices/lab_wire.sym} 3200 1590 1 0 {name=l78 sig_type=std_logic lab=Q1D}
C {devices/lab_wire.sym} 2982.5 1750 0 0 {name=l74 sig_type=std_logic lab=Q2D}
C {devices/lab_wire.sym} 2600 1780 0 0 {name=l62 sig_type=std_logic lab=out}
C {DC_DC_Converter/BUFFER/BUFFER_NMOS/BUFFER_N.sym} 3430 1670 0 1 {name=X5}
C {devices/lab_wire.sym} 3295 1655 0 1 {name=l81 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3295 1535 0 1 {name=l83 sig_type=std_logic lab=VDD}
C {DC_DC_Converter/BUFFER/BUFFER_NMOS/BUFFER_N.sym} 3320 2040 0 1 {name=X6}
C {devices/lab_wire.sym} 3185 2025 0 1 {name=l85 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3185 1905 0 1 {name=l92 sig_type=std_logic lab=VDD}
C {devices/code.sym} 1083 944 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval(@value )"
value="** manual skywater pdks install (with patches applied)
* .lib \\\\$::SKYWATER_MODELS\\\\/models/sky130.lib.spice tt

** opencircuitdesign pdks install
.lib \\\\$::SKYWATER_MODELS\\\\/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false}
C {devices/ind.sym} 1940 980 3 0 {name=L2
m=1
value=100n
footprint=1206
device=inductor}
C {devices/capa.sym} 2030 1030 0 0 {name=C2
m=1
value=3n
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 2090 980 0 0 {name=l80 sig_type=std_logic lab=out}
C {devices/lab_wire.sym} 1890 980 0 0 {name=l82 sig_type=std_logic lab=IL}
C {devices/lab_wire.sym} 2410 690 0 0 {name=l93 sig_type=std_logic lab=IBIAS1}
C {devices/isource.sym} 2410 760 0 0 {name=I4 value=50u}
C {devices/vsource.sym} 2220 760 0 0 {name=V11 value=1.8}
C {devices/gnd.sym} 2220 790 0 0 {name=l95 lab=GND}
C {devices/vsource.sym} 2310 760 0 0 {name=V13 value=0}
C {devices/gnd.sym} 2310 790 0 0 {name=l99 lab=GND}
C {devices/lab_wire.sym} 2310 720 0 0 {name=l100 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2110 1300 0 1 {name=l101 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1810 1090 0 0 {name=l102 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2130 1460 0 1 {name=l104 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2100 1460 0 0 {name=l105 sig_type=std_logic lab=IBIAS1}
C {devices/lab_wire.sym} 1730 1300 0 1 {name=l106 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1730 1470 0 1 {name=l107 sig_type=std_logic lab=VSS}
C {devices/vsource.sym} 2120 760 0 0 {name=V14 value=0.9}
C {devices/gnd.sym} 2120 790 0 0 {name=l108 lab=GND}
C {devices/lab_wire.sym} 2120 720 0 0 {name=l109 sig_type=std_logic lab=VREF}
C {devices/lab_wire.sym} 1710 1300 0 0 {name=l110 sig_type=std_logic lab=IBIAS2}
C {devices/lab_wire.sym} 2330 1230 0 0 {name=l114 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2230 1360 0 0 {name=l115 sig_type=std_logic lab=VREF}
C {devices/lab_wire.sym} 1890 1370 0 0 {name=l116 sig_type=std_logic lab=SAWTOOTH}
C {devices/lab_wire.sym} 2600 1110 0 0 {name=l117 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/pfet_01v8.sym} 2750 1010 0 1 {name=M4
L=0.15
W=10
nf=1
mult=450
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 2730 1150 0 0 {name=l118 sig_type=std_logic lab=VSS}
C {devices/vsource.sym} 2840 1060 0 0 {name=V16 value="pwl(0 1.8 3.5us 1.8 3.51us 0 7us 0) r=0"}
C {devices/gnd.sym} 2840 1090 0 0 {name=l119 lab=GND}
C {devices/gnd.sym} 2840 1090 0 0 {name=l120 lab=GND}
C {devices/lab_wire.sym} 1540 1300 0 1 {name=l121 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1540 1460 0 1 {name=l122 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/BUFFER/BUFFER_PMOS/BUFFER_P.sym} 1410 970 0 0 {name=X7}
C {devices/lab_wire.sym} 1475 860 0 0 {name=l123 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1475 982.5 0 0 {name=l124 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1605 1105 0 0 {name=l125 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1605 985 0 0 {name=l126 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1670 920 0 0 {name=l127 sig_type=std_logic lab=V_P}
C {devices/lab_wire.sym} 1720 1040 0 0 {name=l128 sig_type=std_logic lab=V_N}
C {devices/lab_wire.sym} 2830 1010 0 0 {name=l129 sig_type=std_logic lab=DL}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2130 1120 3 0 {name=C4 model=cap_mim_m3_1 W=3.4 L=4 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2220 1230 3 0 {name=C7 model=cap_mim_m3_1 W=22 L=22.5 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2480 1090 0 0 {name=C8 model=cap_mim_m3_1 W=9.8 L=9.9 MF=1 spiceprefix=X}
C {devices/lab_wire.sym} 2220 700 0 0 {name=l130 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2670 1010 0 0 {name=l131 sig_type=std_logic lab=VDD}
C {DC_DC_Converter/Comparator/Comp_lvt.sym} 1810 1450 0 1 {name=XM5}
C {devices/lab_wire.sym} 2080 1260 3 0 {name=l132 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2450 1020 0 0 {name=l133 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2300 1030 0 0 {name=l134 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2300 1170 0 0 {name=l135 sig_type=std_logic lab=VSS}
C {devices/res.sym} 1920 1100 1 0 {name=R8
value=40m
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 2600 1050 0 0 {name=R9
value=40
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 2730 1100 0 0 {name=R10
value=4
footprint=1206
device=resistor
m=1}
C {DC_DC_Converter/BUFFER/BUFFER_NMOS/BUFFER_N.sym} 1470 1120 0 0 {name=X8}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2080 1230 3 0 {name=R11
W=0.35
L=18.19
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2330 1030 0 0 {name=R12
W=0.35
L=45.9
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2330 1170 0 0 {name=R13
W=0.35
L=414
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_wire.sym} 2540 690 0 0 {name=l136 sig_type=std_logic lab=IBIAS2}
C {devices/isource.sym} 2540 760 0 0 {name=I5 value=50u}
C {devices/lab_wire.sym} 1400 1210 0 0 {name=l137 sig_type=std_logic lab=PH1}
C {devices/lab_wire.sym} 1300 1210 0 0 {name=l138 sig_type=std_logic lab=PH2}
C {devices/lab_wire.sym} 2540 810 0 0 {name=l139 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2410 810 0 0 {name=l140 sig_type=std_logic lab=VSS}
C {sky130_fd_pr/res_xhigh_po_0p35.sym} 2480 1020 0 0 {name=R14
W=0.35
L=1.47
model=res_xhigh_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_wire.sym} 3300 800 0 0 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3390 800 0 0 {name=l7 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} 2780 1590 0 0 {name=l8 sig_type=std_logic lab=VDD}
C {DC_DC_Converter/Folded_OPAMP/Folded_OPAMP_2.sym} 2330 1540 0 1 {name=XM2}
C {devices/lab_wire.sym} 3365 1905 0 1 {name=l1 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3365 2025 0 1 {name=l3 sig_type=std_logic lab=VSS}
C {DC_DC_Converter/Non_Overlap_Clk/Non_over_clk.sym} 1740 1640 0 1 {name=x1}
C {Power_mosfets.sym} 1810 810 0 0 {name=x2}
C {devices/lab_wire.sym} 1840 640 0 0 {name=l4 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1690 780 0 0 {name=l5 sig_type=std_logic lab=V_P}
C {devices/lab_wire.sym} 1700 820 0 0 {name=l6 sig_type=std_logic lab=V_N}
C {devices/lab_wire.sym} 1990 810 0 0 {name=l9 sig_type=std_logic lab=IL}
